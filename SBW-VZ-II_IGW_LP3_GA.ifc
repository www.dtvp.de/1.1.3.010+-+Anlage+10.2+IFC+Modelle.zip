Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2026-07-17T10:15:17+02:00
Author: Bra
Organization: IGW
Written by: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)
Made in: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)

# IfcSite: Projektstandort, Default
RefLatitude: 49, 0, 3571; RefLongitude: 12, 15, -2; RefElevation: 0 m

# IfcBuilding: Gebäude, Speiseverteilzentrum SBW VZ II
Description: Speiseverteilzentrum SBW VZ II

# IfcBuildingStorey: Geschoss (4)
In: Speiseverteilzentrum SBW VZ II
Name | Description | Elevation (m)
Wartung_FFB | 2 | 7.1307
UK Thermische Hülle | 1 | 6.2307
EG_Verwaltung_FFB | 0 | 0.115653
Grundleitungsebene | -1 | -1.884

# IfcBuildingElementProxy: IfcProxy (8)
Description: IfcProxy
Name | In
IfcProxy | Wartung_FFB
7 x IfcProxy | EG_Verwaltung_FFB

# IfcDistributionElement: ASP01
In: EG_Verwaltung_FFB
Description: ASP01
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: ASP01

# IfcDistributionElement: ASP02
In: EG_Verwaltung_FFB
Description: ASP02
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: ASP02

# IfcDistributionElement: ASP03
In: EG_Verwaltung_FFB
Description: ASP03
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: ASP03

# IfcFlowFitting: Quader (64)
Description: Quader
Pset_MEP - Name: Quader
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Name | In
26 x Quader | Wartung_FFB
38 x Quader | EG_Verwaltung_FFB
