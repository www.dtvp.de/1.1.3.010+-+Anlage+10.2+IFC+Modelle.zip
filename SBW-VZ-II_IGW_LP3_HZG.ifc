Properties of the parts of a building model (IFC2X3), part 7 of 7

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 736.366 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1852.99 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2345 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 183.722 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 39.8809 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 75.7079 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1128.75 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.266 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 230.708 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
6 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1142.67 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 165 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3779.81 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 115 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3691 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1046.67 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2735 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 392.081 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
6 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1093.67 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 165 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3823.14 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 115 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3698.5 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1422.26 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 136.5 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1935 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 133.988 | 20 | 15 | 21.3 | 17.3 | 81.3709 | 82.2194 | 0.177017 | 0.112184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 146 | 20 | 20 | 26.9 | 22.3 | 454.945 | 459.689 | 0.879686 | 0.345265 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1705.52 | 20 | 20 | 26.9 | 22.3 | 454.945 | 459.689 | 0.879686 | 0.345265 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.5 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 412.074 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1260.78 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2735 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 181.099 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 160.656 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.5 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 462.074 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1075.69 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1930 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 166.001 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 146 | 20 | 20 | 26.9 | 22.3 | 454.945 | 459.689 | 0.879686 | 0.345265 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2050.57 | 20 | 20 | 26.9 | 22.3 | 454.945 | 459.689 | 0.879686 | 0.345265 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 36.0356 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2010 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 630.419 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 73.5 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 202.759 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2815 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 460.419 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 73.5 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 142.06 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4958.3 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 597.926 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 627.4 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2130 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.118 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 13.797 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 482.06 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4958.3 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 547.926 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 812.497 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2935 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.216 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.797 | 20 | 15 | 21.3 | 17.3 | 151.552 | 153.133 | 0.526101 | 0.208941 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82

# IfcFlowSegment: Wickelfalzrohr (4)
In: EG_Verwaltung_FFB
Description: Wickelfalzrohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Wickelfalzrohr; Abbreviation: R-R
Name | Geom-Diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium
Wickelfalzrohr | 200 | 1916.51 | L_Zuluft
Wickelfalzrohr | 250 | 1816.51 | L_Abgas
Wickelfalzrohr | 200 | 1218.05 | L_Zuluft
Wickelfalzrohr | 250 | 1118.05 | L_Abgas

# IfcFlowStorageDevice: Puffer (2)
In: EG_Verwaltung_FFB
Description: Puffer
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Puffer; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Info | Room | Room No.
Puffer | 4400 kg | Wasserversorgung | 01.00.022
Puffer | 5500 kg | Heizzentrale | 01.00.023

# IfcFlowTerminal: GK 1
In: EG_Verwaltung_FFB
Description: GK 1

# IfcFlowTerminal: GK 2
In: EG_Verwaltung_FFB
Description: GK 2

# IfcFlowTerminal: Pufferspeicher (2)
In: EG_Verwaltung_FFB
Description: Pufferspeicher

# IfcFlowTerminal: RLT-Anlage 01 - Spülküche, Diatküche (2)
In: Wartung_FFB
Description: RLT-Anlage 01 - Spülküche, Diatküche
Name
RLT-Anlage 01 - Spülküche, Diatküche | Pset_MEP - Name: RLT-Anlage 01 - Spülküche, Diatküche; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage 01 - Spülküche, Diatküche

# IfcFlowTerminal: RLT-Anlage 02 - Lager / Werkstatt (2)
In: Wartung_FFB
Description: RLT-Anlage 02 - Lager / Werkstatt
Name
RLT-Anlage 02 - Lager / Werkstatt | Pset_MEP - Name: RLT-Anlage 02 - Lager / Werkstatt; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage 02 - Lager / Werkstatt

# IfcFlowTerminal: RLT-Anlage 03 - Büro + Aufenthaltsräume (2)
In: Wartung_FFB
Description: RLT-Anlage 03 - Büro + Aufenthaltsräume
Name
RLT-Anlage 03 - Büro + Aufenthaltsräume | Pset_MEP - Name: RLT-Anlage 03 - Büro + Aufenthaltsräume; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage 03 - Büro + Aufenthaltsräume

# IfcFlowTerminal: RLT-Anlage 04 - Halle (2)
In: Wartung_FFB
Description: RLT-Anlage 04 - Halle
Name
RLT-Anlage 04 - Halle | Pset_MEP - Name: RLT-Anlage 04 - Halle; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage 04 - Halle

# IfcFlowTerminal: RLT-Anlage 05 - Technik (2)
In: Wartung_FFB
Description: RLT-Anlage 05 - Technik
Name
RLT-Anlage 05 - Technik | Pset_MEP - Name: RLT-Anlage 05 - Technik; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage 05 - Technik

# IfcFlowTerminal: RLT-Anlage Kaltarbeitsplätze (2)
In: Wartung_FFB
Description: RLT-Anlage Kaltarbeitsplätze
Name
RLT-Anlage Kaltarbeitsplätze | Pset_MEP - Name: RLT-Anlage Kaltarbeitsplätze; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage Kaltarbeitsplätze

# IfcFlowTerminal: RLT-Anlage Warmarbeitsplätze (2)
In: Wartung_FFB
Description: RLT-Anlage Warmarbeitsplätze
Name
RLT-Anlage Warmarbeitsplätze | Pset_MEP - Name: RLT-Anlage Warmarbeitsplätze; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
RLT-Anlage Warmarbeitsplätze

# IfcFlowTerminal: Verbraucher (18)
Description: Verbraucher
Name | In
4 x Verbraucher | Wartung_FFB | Pset_MEP - Name: Verbraucher; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
4 x Verbraucher | Wartung_FFB
10 x Verbraucher | EG_Verwaltung_FFB

# IfcFlowTerminal: WW-WP
In: EG_Verwaltung_FFB
Description: WW-WP

# IfcFlowTreatmentDevice: Luft-Wasser-Wärmepumpe (4)
In: Wartung_FFB
Description: Luft-Wasser-Wärmepumpe
Pset_MEP - Name: Luft-Wasser-Wärmepumpe; Info: 5600 kg; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.

# IfcProxy: Anlage Sanitär
Description: Anlage Sanitär; ProxyType: PRODUCT
Pset_MEP - Name: Anlage Sanitär

# IfcProxy: GK 1
Description: GK 1; ProxyType: PRODUCT
Pset_MEP - Name: GK 1; Room: Kleinkältemaschinenraum; Room No.: 01.00.034; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: GK 2
Description: GK 2; ProxyType: PRODUCT
Pset_MEP - Name: GK 2; Room: Kleinkältemaschinenraum; Room No.: 01.00.034; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: Netzendpunkt Sanitär
Description: Netzendpunkt Sanitär; ProxyType: PRODUCT

# IfcProxy: Pufferspeicher (2)
Description: Pufferspeicher; ProxyType: PRODUCT
Pset_MEP - Name: Pufferspeicher; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Room | Room No.
Pufferspeicher | Heizzentrale | 01.00.023
Pufferspeicher | Wasserversorgung | 01.00.022

# IfcProxy: Verbraucher (10)
Description: Verbraucher; ProxyType: PRODUCT
Pset_MEP - Name: Verbraucher; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Room | Room No.
2 x Verbraucher | Lager / Lebensmittel | 01.00.054
Verbraucher | Lager / Lebensmittel | 01.00.053
3 x Verbraucher | Ausgabe | 01.00.049
Verbraucher | Lager | 01.00.050.1
2 x Verbraucher | Annahme | 01.00.045
Verbraucher | Annahme | 01.00.044

# IfcProxy: WW-WP
Description: WW-WP; ProxyType: PRODUCT
Pset_MEP - Name: WW-WP; Room: Heizzentrale; Room No.: 01.00.023; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: Zentrale (7)
Description: Zentrale; ProxyType: PRODUCT
Pset_MEP - Name: Zentrale; Room: Heizzentrale; Room No.: 01.00.023; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
