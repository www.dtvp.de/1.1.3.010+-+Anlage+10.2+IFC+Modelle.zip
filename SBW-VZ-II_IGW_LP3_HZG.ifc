Properties of the parts of a building model (IFC2X3), part 5 of 7

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 172.905 | 20 | 15 | 21.3 | 17.3 | 92.799 | 93.7667 | 0.222359 | 0.127939 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 352.5 | 20 | 15 | 21.3 | 17.3 | 92.799 | 93.7667 | 0.222359 | 0.127939 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 182.5 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 281.94 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 55.5613 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2960 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 271.764 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2206.12 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1723.55 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 166.867 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 332.038 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 16.5 | 20 | 15 | 21.3 | 17.3 | 177.927 | 179.782 | 0.699731 | 0.245303 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 924.5 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1724.37 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 371.764 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2260 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.927 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 80.0539 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 924.5 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1962.38 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 266.867 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3065 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 173.024 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 247.554 | 20 | 15 | 21.3 | 17.3 | 96.6899 | 97.6982 | 0.238841 | 0.133304 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1720.89 | 20 | 15 | 21.3 | 17.3 | 176.303 | 178.141 | 0.688385 | 0.243064 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 424.5 | 20 | 15 | 21.3 | 17.3 | 176.303 | 178.141 | 0.688385 | 0.243064 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 48.0613 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2960 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 446.635 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 435.226 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 187.042 | 20 | 15 | 21.3 | 17.3 | 53.9745 | 54.5373 | 0.0538302 | 0.0744131 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3557.5 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 326.64 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 464.665 | 20 | 15 | 21.3 | 17.3 | 128.106 | 129.442 | 0.390949 | 0.176617 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1242.88 | 20 | 15 | 21.3 | 17.3 | 176.303 | 178.141 | 0.688385 | 0.243064 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 424.5 | 20 | 15 | 21.3 | 17.3 | 176.303 | 178.141 | 0.688385 | 0.243064 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 737.5 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 54.2468 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 158.572 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3445 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 329.045 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 77.5 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 132.5 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 139.247 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 158.572 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2840 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 449.041 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 77.5 | 20 | 15 | 21.3 | 17.3 | 48.1966 | 48.6992 | 0.0480677 | 0.0664473 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 182.5 | 20 | 15 | 21.3 | 17.3 | 74.1319 | 74.9049 | 0.150692 | 0.102204 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 239.234 | 20 | 15 | 21.3 | 17.3 | 74.1319 | 74.9049 | 0.150692 | 0.102204 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 224.5 | 20 | 15 | 21.3 | 17.3 | 176.464 | 178.304 | 0.689505 | 0.243286 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 490.14 | 20 | 15 | 21.3 | 17.3 | 176.464 | 178.304 | 0.689505 | 0.243286 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 495.706 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2710 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 160.913 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 81.6943 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 630.804 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3515 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 176.01 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 236.694 | 20 | 15 | 21.3 | 17.3 | 137.813 | 139.25 | 0.444682 | 0.189999 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 968.149 | 20 | 15 | 21.3 | 17.3 | 176.464 | 178.304 | 0.689505 | 0.243286 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 224.5 | 20 | 15 | 21.3 | 17.3 | 176.464 | 178.304 | 0.689505 | 0.243286 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 335.028 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 630.804 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3765 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 148.51 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 145.278 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 335.028 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 495.706 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2960 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 133.413 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 230.278 | 20 | 15 | 21.3 | 17.3 | 38.6507 | 39.0537 | 0.0385474 | 0.0532867 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 417 | 20 | 20 | 26.9 | 22.3 | 284.316 | 287.28 | 0.378083 | 0.215772 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 665.315 | 20 | 20 | 26.9 | 22.3 | 284.316 | 287.28 | 0.378083 | 0.215772 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1839.14 | 20 | 20 | 26.9 | 22.3 | 284.316 | 287.28 | 0.378083 | 0.215772 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 583.205 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 271.764 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3060 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 490.16 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 543.03 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 166.867 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 125.175 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 540.258 | 20 | 15 | 21.3 | 17.3 | 102.253 | 103.319 | 0.263316 | 0.140973 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 417 | 20 | 20 | 26.9 | 22.3 | 284.316 | 287.28 | 0.378083 | 0.215772 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 593.31 | 20 | 20 | 26.9 | 22.3 | 284.316 | 287.28 | 0.378083 | 0.215772 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1839.14 | 20 | 20 | 26.9 | 22.3 | 284.316 | 287.28 | 0.378083 | 0.215772 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 103.5 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 509.234 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3415 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 154.397 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 263.543 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 103.5 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 629.23 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2910 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 154.397 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 348.543 | 20 | 15 | 21.3 | 17.3 | 182.063 | 183.962 | 0.729013 | 0.251005 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 424.5 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1155.15 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 689.159 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3052.5 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 57.5 | 20 | 15 | 21.3 | 17.3 | 37.0855 | 37.4722 | 0.0369864 | 0.0511288 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 212.06 | 20 | 15 | 21.3 | 17.3 | 37.0855 | 37.4722 | 0.0369864 | 0.0511288 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 424.5 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 789.787 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 584.257 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 130.861 | 20 | 15 | 21.3 | 17.3 | 159.782 | 161.448 | 0.577842 | 0.220287 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 424.5 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1155.15 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 679.918 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3152.5 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 214.128 | 20 | 15 | 21.3 | 17.3 | 73.8347 | 74.6046 | 0.149651 | 0.101794 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 424.5 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 816.637 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 559.926 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 104.011 | 20 | 15 | 21.3 | 17.3 | 193.349 | 195.365 | 0.811719 | 0.266564 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 507.024 | 20 | 15 | 21.3 | 17.3 | 119.514 | 120.76 | 0.346017 | 0.164771 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 724.5 | 20 | 15 | 21.3 | 17.3 | 244.05 | 246.595 | 1.23356 | 0.336465 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 244.05 | 246.595 | 1.23356 | 0.336465 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 14.497 | 20 | 15 | 21.3 | 17.3 | 244.05 | 246.595 | 1.23356 | 0.336465 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1538.85 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 525.781 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1815 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 154.583 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 877.5 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1808.85 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 660.879 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3515 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 169.681 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 126.837 | 20 | 15 | 21.3 | 17.3 | 51.6181 | 52.1564 | 0.0514801 | 0.0711645 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 724.5 | 20 | 15 | 21.3 | 17.3 | 244.05 | 246.595 | 1.23356 | 0.336465 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 244.05 | 246.595 | 1.23356 | 0.336465 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 326.497 | 20 | 15 | 21.3 | 17.3 | 244.05 | 246.595 | 1.23356 | 0.336465 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 80.5454 | 81.3853 | 0.17392 | 0.111046 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1682.52 | 20 | 15 | 21.3 | 17.3 | 80.5454 | 81.3853 | 0.17392 | 0.111046 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2393.13 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3015 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 130.839 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 154.722 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2523.13 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2210 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 130.839 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 222.222 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 577.5 | 20 | 15 | 21.3 | 17.3 | 43.8314 | 44.2884 | 0.0437142 | 0.0604291 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 80.5454 | 81.3853 | 0.17392 | 0.111046 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1702.52 | 20 | 15 | 21.3 | 17.3 | 80.5454 | 81.3853 | 0.17392 | 0.111046 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1015.01 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 301.926 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2060 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 185.894 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 188.536 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1015.01 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 416.828 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2865 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 170.796 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 121.036 | 20 | 15 | 21.3 | 17.3 | 36.714 | 37.0968 | 0.0366159 | 0.0506166 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5599.62 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 65 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1248.27 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3165 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 160.714 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 141.2 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5854.95 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 65 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1383.17 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2360 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 127.327 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 175.811 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 61.703 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 877.5 | 20 | 15 | 21.3 | 17.3 | 111.887 | 113.053 | 0.308221 | 0.154255 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 434.5 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1155.15 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 676.571 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3152.5 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 605.44 | 20 | 15 | 21.3 | 17.3 | 85.1564 | 86.0444 | 0.191526 | 0.117403 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 434.5 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 828.252 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 571.669 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 92.3957 | 20 | 15 | 21.3 | 17.3 | 155.351 | 156.971 | 0.549704 | 0.214178 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 339.73 | 20 | 15 | 21.3 | 17.3 | 70.1942 | 70.9261 | 0.137164 | 0.0967747 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 434.5 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1155.15 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 316.364 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3152.5 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 335.271 | 20 | 15 | 21.3 | 17.3 | 66.4073 | 67.0998 | 0.124686 | 0.0915539 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 434.5 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 802.347 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 211.461 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 118.301 | 20 | 15 | 21.3 | 17.3 | 157.054 | 158.691 | 0.560442 | 0.216526 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 586.126 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 59.5 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1155.15 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 316.364 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3535 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 300.449 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 797.597 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 211.461 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4055 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 110.051 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 368.047 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 68.5 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 300.945 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 826.557 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 90.0912 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 368.543 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 68.5 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1155.15 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 541.154 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3535 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 272.437 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 826.557 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 423.991 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4055 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 90.0912 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 327.774 | 20 | 15 | 21.3 | 17.3 | 130.143 | 131.5 | 0.401961 | 0.179424 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 68.5 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 736.887 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3135 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 165.499 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 240.972 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 877.5 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 590.485 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4055 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 180.597 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 173.472 | 20 | 15 | 21.3 | 17.3 | 67.743 | 68.4494 | 0.129027 | 0.0933954 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 32.5 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 140.702 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 171.259 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3130 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3107.99 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 77.5 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 32.5 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 55.7015 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 171.259 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3935 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2957.99 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 77.5 | 20 | 15 | 21.3 | 17.3 | 161.483 | 163.167 | 0.588813 | 0.222632 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3170 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3299.36 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1340.21 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3578.04 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1756.79 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3079.43 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 83 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1889.02 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1198 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 964 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 300 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4479.86 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 935.441 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 265 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
