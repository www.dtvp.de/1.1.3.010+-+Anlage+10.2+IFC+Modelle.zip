Properties of the parts of a building model (IFC2X3), part 2 of 7

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | Wartung_FFB | 2821.1 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 944 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1178.65 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 157.43 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 84.9774 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 442.526 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 119 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
2 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 1750.12 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 325.887 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 696 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 1634.65 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 805 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
2 x Rohr DIN EN 10220 | Wartung_FFB | 575 | 100 | 125 | 139.7 | 131.7 | 44154.5 | 44614.9 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 540.332 | 100 | 125 | 139.7 | 131.7 | 44154.5 | 44614.9 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
2 x Rohr DIN EN 10220 | Wartung_FFB | 575 | 100 | 125 | 139.7 | 131.7 | 44154.5 | 44614.9 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1140.33 | 100 | 125 | 139.7 | 131.7 | 44154.5 | 44614.9 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 435.668 | 100 | 125 | 139.7 | 131.7 | 44154.5 | 44614.9 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1035.67 | 100 | 125 | 139.7 | 131.7 | 44154.5 | 44614.9 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
2 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 1740.12 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 325.887 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 696 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 1634.65 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 805 | 100 | 150 | 168.3 | 159.3 | 88308.9 | 89229.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 186.545 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1402.86 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 119 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1047 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 194 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3011.65 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
6 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 2221.1 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 944 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 738.748 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 135.434 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 219 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 176.724 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
5 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 5385.84 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1716 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
2 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 2472.58 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 2264.54 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 805 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 575 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 673.032 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 575 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1273.03 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 327.967 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 550 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 927.967 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 550 | 100 | 125 | 139.7 | 131.7 | 46308.3 | 46791.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
2 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 3662.58 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 2264.54 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 805 | 100 | 150 | 168.3 | 159.3 | 92616.7 | 93582.5 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 219 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 186.641 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
5 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 5493.92 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1255 | 100 | 200 | 219.1 | 206.5 | 0 | 0 | 0 |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 4068 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
11 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 512.171 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 1187.04 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2487.22 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 1250 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 1180.77 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 1898.69 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 314.069 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 2775 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 2187.22 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 1250 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 880.774 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 1703.69 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 319.069 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 2775 | 30 | 25 | 33.7 | 28.5 | 624.624 | 631.138 |  |  | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | Wartung_FFB | 4068 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
11 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 712.171 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 1787.04 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2768 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 243.365 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 172.526 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2790.62 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 436 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 4879.56 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 720 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2768 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 243.365 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 472.526 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 3390.62 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 436 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 5379.56 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 720 | 40 | 32 | 42.4 | 37.2 | 1281.56 | 1294.92 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
2 x Rohr DIN EN 10220 | Wartung_FFB | 1598 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
3 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 3591.25 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 676.954 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 2931.95 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 3173.29 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 744.428 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 223.163 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
2 x Rohr DIN EN 10220 | Wartung_FFB | 1598 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
3 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 4051.25 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 616.954 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 2931.95 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 3933.29 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 1204.43 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | Wartung_FFB | 223.163 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
2 x Rohr DIN EN 10220 | Wartung_FFB | 2913 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 363.093 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
4 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1476.29 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1712.27 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 138.356 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
2 x Rohr DIN EN 10220 | Wartung_FFB | 2913 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 813.093 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
4 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1476.29 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 1262.27 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 138.356 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | Wartung_FFB | 3162 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 1140.32 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 3723.27 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 205 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 4121.77 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2583.14 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 574.587 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 162.201 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 3468 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 4180.2 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2649.85 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 774.587 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 162.201 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 3468 | 40 | 32 | 42.4 | 37.2 | 2272.34 | 2296.04 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 3162 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 1398.74 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 3789.97 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 205 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | Wartung_FFB | 2821.96 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 486 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 177.506 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 156.315 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 258.432 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2918 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 3310.39 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 486 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 710.804 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 386.315 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 258.432 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | Wartung_FFB | 2918 | 40 | 32 | 42.4 | 37.2 | 1550.79 | 1566.96 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
2 x Rohr DIN EN 10220 | Wartung_FFB | 1999 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
2 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 3413.81 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 203.283 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 326.962 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 451.989 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
2 x Rohr DIN EN 10220 | Wartung_FFB | 1999 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
2 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 3713.81 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 803.283 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 626.962 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 451.989 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | Wartung_FFB | 3867 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3867 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 382.688 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 498 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1302.3 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1869.17 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1926 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 458 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 305.135 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1484.36 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 358.424 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 498 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 748 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3024.57 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2869.17 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1926 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 458 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 180.135 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 155.135 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 275 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1484.36 | 100 | 125 | 139.7 | 131.7 | 53846.9 | 54408.4 | 0.877251 | 1.14391 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 666.014 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2071.32 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 384.539 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3013 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3165.31 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 833 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4853.01 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 374 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 666.014 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 578.298 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 553.298 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 319.727 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 384.539 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3013 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3215.31 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5153.01 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 324 | 80 | 80 | 88.9 | 82.5 | 14213.1 | 14493.6 | 0.734641 | 0.783228 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 340.75 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 163.75 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2362.02 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1926 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 458 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 607.977 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1112.94 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 437.425 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 273 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 498 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1148 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 801.765 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2337.76 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2326 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 458 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 340.954 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 250 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 225 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1512.94 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 837.425 | 100 | 125 | 139.7 | 131.7 | 40923.7 | 41350.4 | 0.521556 | 0.869375 | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 314 | 100 | 150 | 168.3 | 159.3 | 79262.7 | 80089.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 564 | 100 | 150 | 168.3 | 159.3 | 40105.2 | 40523.4 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 441 | 70 | 65 | 76.1 | 70.3 | 10446.3 | 10555.2 |  |  | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 414 | 100 | 150 | 168.3 | 159.3 | 79262.7 | 80089.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 614 | 100 | 150 | 168.3 | 159.3 | 40105.2 | 40523.4 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 291 | 70 | 65 | 76.1 | 70.3 | 10446.3 | 10555.2 |  |  | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 795.342 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 96.9218 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1772.94 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1056.47 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 459.529 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 241.946 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 410 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 684 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 248 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4384 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4397 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 274 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 712 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 683 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4308 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 96 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 673 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 663 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4283 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 46 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 648 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 657 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4403 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 286 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 768 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 379 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 948 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 58.5124 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 519.285 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 456.636 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2897.2 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1439.93 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 476.073 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 541.946 | 100 | 150 | 168.3 | 159.3 | 81168.8 | 82015.2 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 410 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 684 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 248 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4384 | 60 | 50 | 60.3 | 54.5 | 6623.17 | 6692.23 |  |  | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4397 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 274 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 712 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 683 | 50 | 40 | 48.3 | 43.1 | 3823.13 | 3863 |  |  | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4308 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 96 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 673 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 663 | 100 | 125 | 139.7 | 131.7 | 29658.9 | 29968.2 |  |  | DN 125 | 139.7 x 4 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4283 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 46 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 648 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 657 | 100 | 150 | 168.3 | 159.3 | 39157.5 | 39565.8 |  |  | DN 150 | 168.3 x 4.5 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4403 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 286 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
