Properties of the parts of a building model (IFC2X3), part 6 of 7

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2611.04 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 343.954 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.798 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85.1087 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 891.441 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 265 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2321.04 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 164.857 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2345 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.7 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 170.109 | 20 | 15 | 21.3 | 17.3 | 130.694 | 132.057 | 0.404964 | 0.180184 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4083.87 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 300 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 34.202 | 20 | 20 | 26.9 | 22.3 | 325.227 | 328.619 | 0.480641 | 0.24682 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3170 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2556.36 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1283.21 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3603.04 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1731.79 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3054.87 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 83 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1671.02 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1198 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1134 | 60 | 50 | 60.3 | 54.5 | 4089.64 | 4132.29 | 0.596997 | 0.518334 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2635.1 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 109.941 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 502.567 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5184.94 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1480.57 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 194.5 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 242.26 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 39.2304 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 208.743 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 55 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3833.68 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5335.46 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1700.89 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3195 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 149.623 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 220.124 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3819.68 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5001.46 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1501.99 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4000 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 164.72 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 135.124 | 20 | 15 | 21.3 | 17.3 | 80.0416 | 80.8763 | 0.172043 | 0.110351 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5032.57 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 643.657 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 713.536 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 723.173 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 650 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4354.26 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5751.15 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 824.475 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3300 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.703 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 165.777 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5511.15 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 659.377 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2695 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 138.605 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 10.7775 | 20 | 15 | 21.3 | 17.3 | 30.3833 | 30.7001 | 0.0303021 | 0.0418886 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 673.173 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 650 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4368.26 | 20 | 20 | 26.9 | 22.3 | 329.784 | 333.223 | 0.492762 | 0.250278 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5032.57 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 643.657 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 713.536 | 30 | 25 | 33.7 | 28.5 | 975.987 | 986.164 | 1.14274 | 0.467985 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
6 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 342.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1865.63 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
3 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 84.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
6 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 342.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1651.63 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
3 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 84.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1871.72 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1657.72 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1192.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1688.62 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 144.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1192.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1474.62 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 144.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 794.5 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2529.36 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 271.764 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2645 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 66.0039 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 821.449 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 794.5 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2623.36 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 166.867 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 186.004 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 871.547 | 20 | 15 | 21.3 | 17.3 | 61.9727 | 62.6189 | 0.110742 | 0.08544 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 794.5 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2529.36 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 271.764 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2645 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 66.0039 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 543.874 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 794.5 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2623.36 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 166.867 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 186.004 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 593.972 | 20 | 15 | 21.3 | 17.3 | 45.7613 | 46.2385 | 0.045639 | 0.0630899 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 542.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 368.407 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 803.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 542.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 582.407 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 803.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 442.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2850.4 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 203.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 442.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2700.4 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 203.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 659.377 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2445 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 138.605 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 79.8097 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 207.5 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 824.475 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3050 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.703 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 234.81 | 20 | 15 | 21.3 | 17.3 | 30.1661 | 30.4806 | 0.0300854 | 0.0415891 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 92.2599 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 39.2304 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5994.74 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 55 | 50 | 40 | 48.3 | 43.1 | 3086.48 | 3118.66 | 1.14705 | 0.628273 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2440.2 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 109.941 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 502.567 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
4 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5427.15 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1480.57 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 102.286 | 50 | 40 | 48.3 | 43.1 | 3184.34 | 3217.54 | 1.21564 | 0.648192 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 322.5 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 418.065 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3630.74 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 575.5 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 322.5 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 223.17 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3673.3 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 575.5 | 20 | 15 | 21.3 | 17.3 | 107.694 | 108.817 | 0.288288 | 0.148475 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 125.5 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4933.35 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 369.239 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3600 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 134.261 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 282.5 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 125.5 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4805.79 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 505.386 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2795 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 148.114 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 132.5 | 20 | 15 | 21.3 | 17.3 | 97.8589 | 98.8793 | 0.243895 | 0.134915 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 581.723 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 795.723 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 484.5 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 864.68 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 265 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1080.69 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 38.693 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 310.684 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 484.5 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 918.68 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 265 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 885.588 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2350 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 51.307 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 260.586 | 20 | 15 | 21.3 | 17.3 | 261.371 | 264.097 | 1.39636 | 0.360345 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 110.71 | 20 | 15 | 21.3 | 17.3 | 153.671 | 155.273 | 0.539209 | 0.211862 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 279.94 | 20 | 15 | 21.3 | 17.3 | 153.671 | 155.273 | 0.539209 | 0.211862 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 807.5 | 20 | 15 | 21.3 | 17.3 | 153.671 | 155.273 | 0.539209 | 0.211862 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2996.42 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 241.14 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 115 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 184.424 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 455.303 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 349.885 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2625.12 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 411.14 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2645 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 184.424 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 455.303 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 314.885 | 20 | 15 | 21.3 | 17.3 | 123.804 | 125.095 | 0.36814 | 0.170685 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85.5964 | 20 | 15 | 21.3 | 17.3 | 153.671 | 155.273 | 0.539209 | 0.211862 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 105.729 | 20 | 15 | 21.3 | 17.3 | 153.671 | 155.273 | 0.539209 | 0.211862 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 807.5 | 20 | 15 | 21.3 | 17.3 | 153.671 | 155.273 | 0.539209 | 0.211862 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3823.98 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 412.679 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2345 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 194.468 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 138.028 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3182.68 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 257.777 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 209.566 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 53.0282 | 20 | 15 | 21.3 | 17.3 | 29.8672 | 30.1786 | 0.0297873 | 0.0411771 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1548.49 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 94.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1762.49 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 94.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2350.79 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 103.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2564.79 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 103.5 | 20 | 15 | 21.3 | 17.3 | 269.235 | 272.042 | 1.47337 | 0.371186 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2362.09 | 20 | 20 | 26.9 | 22.3 | 472.386 | 477.312 | 0.941792 | 0.358501 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 300 | 20 | 20 | 26.9 | 22.3 | 472.386 | 477.312 | 0.941792 | 0.358501 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 18.7852 | 20 | 20 | 26.9 | 22.3 | 472.386 | 477.312 | 0.941792 | 0.358501 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 289.452 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
3 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3269.65 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2064.5 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1665 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1401.45 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1881.34 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2560 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 100 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 176.193 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 44.6304 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 289.452 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
3 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3249.65 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2214.5 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1665 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1521.45 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2041.12 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3360 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 220 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 185.975 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 62.1304 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 15.3144 | 20 | 20 | 26.9 | 22.3 | 472.386 | 477.312 | 0.941792 | 0.358501 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 300 | 20 | 20 | 26.9 | 22.3 | 472.386 | 477.312 | 0.941792 | 0.358501 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2189.5 | 20 | 20 | 26.9 | 22.3 | 472.386 | 477.312 | 0.941792 | 0.358501 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 253.5 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1143.85 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.364 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 376.847 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 253.5 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 958.755 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2345 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 153.266 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 221.847 | 20 | 15 | 21.3 | 17.3 | 194.533 | 196.562 | 0.82064 | 0.268198 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 253.5 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 996.366 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2018.09 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3150 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 198.82 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 164.881 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 253.5 | 20 | 15 | 21.3 | 17.3 | 138.926 | 140.375 | 0.451046 | 0.191534 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
