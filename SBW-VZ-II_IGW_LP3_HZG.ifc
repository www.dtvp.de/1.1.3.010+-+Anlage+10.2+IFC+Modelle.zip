Properties of the parts of a building model (IFC2X3), part 1 of 7

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2026-07-17T10:12:35+02:00
Author: Bra
Organization: IGW
Written by: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)
Made in: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)

# IfcSite: Projektstandort, Default
RefLatitude: 49, 0, 3571; RefLongitude: 12, 15, -2; RefElevation: 0 m

# IfcSite: Pyramidenstumpf (4)
Description: Pyramidenstumpf
Pset_Basis - Name: Pyramidenstumpf; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Floor | Floor No.
2 x Pyramidenstumpf | Wartung_FFB | 2
2 x Pyramidenstumpf | EG_Verwaltung_FFB | 0

# IfcBuilding: Gebäude, Speiseverteilzentrum SBW VZ II
Description: Speiseverteilzentrum SBW VZ II

# IfcBuildingStorey: Geschoss (4)
In: Speiseverteilzentrum SBW VZ II
Name | Description | Elevation (m)
Wartung_FFB | 2 | 7.1307
UK Thermische Hülle | 1 | 6.2307
EG_Verwaltung_FFB | 0 | 0.115653
Grundleitungsebene | -1 | -1.884

# IfcBuildingElementProxy: IfcProxy (6)
Description: IfcProxy
Name | In
3 x IfcProxy | Wartung_FFB
3 x IfcProxy | EG_Verwaltung_FFB

# IfcBuildingElementProxy: Revisionswolke (2)
In: EG_Verwaltung_FFB
Description: Revisionswolke

# IfcEnergyConversionDevice: Gas-Brennwertkessel
In: EG_Verwaltung_FFB
Description: Gas-Brennwertkessel
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Gas-Brennwertkessel; Info: 350 kg; Room: Heizzentrale; Room No.: 01.00.023; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcEnergyConversionDevice: Gewerbe-
In: EG_Verwaltung_FFB
Description: Gewerbe-
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Gewerbe-; Info: kälte WT; Room: Heizzentrale; Room No.: 01.00.023; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcEnergyConversionDevice: Heizkörper (74)
In: EG_Verwaltung_FFB
Description: Heizkörper
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Catalogue: Kermi Heizkörper 2025/08; Tech-Product line: Flachheizkörper; Calc-Flow temperature (°C): 50 C; Calc-Return temperature (°C): 42 C; Name: Heizkörper; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Height (mm) (mm) | Geom-Depth (mm) (mm) | Geom-Laenge (mm) (mm) | Tech-Article | Tech-Product | Calc-Design volumetric flow (kg/h) (kg/hour) = Calc-Network volumetric flow (kg/h) (kg/hour) | Calc-Q target net (W) (W) | Calc-Q max (W) (W) | Calc-Q actual (W) (W) | Calc-Room temperature (°C) (C) | Room | Room No.
Heizkörper | 505 | 157 | 2305 | PTV300502301L1K | therm-x2 Plan-V Hygiene | 119.514 | 1110.15 | 1128.34 | 1125 | 20 | Dienstraum | 01.00.003
Heizkörper | 505 | 157 | 2005 | PTV300502001L1K | therm-x2 Plan-V Hygiene | 85.1564 | 791.009 | 981.486 | 929.996 | 20 | Dienstraum | 01.00.004
Heizkörper | 505 | 157 | 1805 | PTV300501801L1K | therm-x2 Plan-V Hygiene | 73.8347 | 685.842 | 883.582 | 829.989 | 20 | Dienstraum | 01.00.004
Heizkörper | 505 | 157 | 705 | PTV300500701L1K | therm-x2 Plan-V Hygiene | 37.0855 | 344.483 | 345.111 | 344.996 | 20 | Dienstraum | 01.00.003
Heizkörper | 505 | 157 | 1805 | PTV300501801L1K | therm-x2 Plan-V Hygiene | 70.1942 | 652.026 | 883.582 | 819.992 | 20 | Ruheraum | 01.00.005
Heizkörper | 505 | 157 | 3005 | PTV300503001L1K | therm-x2 Plan-V Hygiene | 130.143 | 1208.88 | 1471 | 1399.98 | 20 | Aufenthalt / Personal | 01.00.006
3 x Heizkörper | 505 | 157 | 2305 | PTV300502301L1K | therm-x2 Plan-V Hygiene | 90.6464 | 842.005 | 1128.34 | 1049.99 | 20 | Aufenthalt / Personal | 01.00.006
Heizkörper | 905 | 157 | 1005 | PTV300901001L1K | therm-x2 Plan-V Hygiene | 67.743 | 629.257 | 795.413 | 749.989 | 20 | Aufenthalt / Personal | 01.00.006
Heizkörper | 905 | 157 | 1205 | PTV300901201L1K | therm-x2 Plan-V Hygiene | 81.5139 | 757.174 | 953.704 | 899.987 | 20 | Aufenthalt / Personal | 01.00.006
Heizkörper | 605 | 157 | 2605 | PTV300602601L1K | therm-x2 Plan-V Hygiene | 122.697 | 1139.72 | 1475.4 | 1399.98 | 20 | Dienstraum | 01.00.002
Heizkörper | 605 | 157 | 3005 | PTV300603001L1K | therm-x2 Plan-V Hygiene | 182.063 | 1691.16 | 1701.94 | 1699.97 | 20 | Dienstraum | 01.00.002
Heizkörper | 605 | 157 | 2605 | PTV300602601L1K | therm-x2 Plan-V Hygiene | 102.253 | 949.814 | 1475.4 | 1339 | 20 | Dienstraum | 01.00.002
Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 137.813 | 1280.13 | 1824.31 | 1649.98 | 20 | Windfang | 01.00.001
Heizkörper | 905 | 157 | 1405 | PTV300901401L1K | therm-x2 Plan-V Hygiene | 74.1319 | 688.603 | 1112 | 970.989 | 20 | Windfang | 01.00.001
Heizkörper | 905 | 102 | 1005 | PTV200901001L1K | therm-x2 Plan-V Hygiene | 38.6507 | 359.022 | 567.714 | 498.999 | 20 | Eingangshalle | 01.00.001.1
2 x Heizkörper | 905 | 157 | 805 | PTV300900801L1K | therm-x2 Plan-V Hygiene | 53.9745 | 501.363 | 637.122 | 599.992 | 20 | Dienstraum | 01.00.015
Heizkörper | 905 | 157 | 2605 | PTV300902601L1K | therm-x2 Plan-V Hygiene | 177.927 | 1652.74 | 2061.74 | 1949.97 | 20 | Dienstraum | 01.00.015
Heizkörper | 705 | 157 | 1805 | PTV300701801L1K | therm-x2 Plan-V Hygiene | 101.952 | 947.022 | 1157.09 | 1099.98 | 20 | Dienstraum | 01.00.016
Heizkörper | 705 | 157 | 905 | PTV300700901L1K | therm-x2 Plan-V Hygiene | 36.9103 | 342.855 | 580.149 | 499.995 | 20 | Dienstraum | 01.00.016
2 x Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 129.778 | 1205.49 | 1461.08 | 1379.99 | 24 | Umkleideraum / Personal / Damen | 01.00.019
Heizkörper | 905 | 157 | 1805 | PTV300901801L1K | therm-x2 Plan-V Hygiene | 79.3075 | 736.678 | 1144.14 | 990.996 | 24 | Waschraum / Damen | 01.00.019.3
Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 79.0134 | 733.947 | 1461.08 | 1156.99 | 24 | Dusche / Personal / Damen | 01.00.019.4
Heizkörper | 905 | 157 | 1405 | PTV300901401L1K | therm-x2 Plan-V Hygiene | 63.8786 | 593.361 | 890.594 | 779.989 | 24 | Dusche / Personal / Herren | 01.00.020.4
Heizkörper | 905 | 157 | 1305 | PTV300901301L1K | therm-x2 Plan-V Hygiene | 58.9557 | 547.633 | 827.207 | 722.997 | 24 | Waschraum / Herren | 01.00.020.3
Heizkörper | 905 | 102 | 1105 | PTV200901101L1K | therm-x2 Plan-V Hygiene | 34.2901 | 318.517 | 500.434 | 431.995 | 24 | Vorraum / Sanitär | 01.00.019.1
Heizkörper | 905 | 102 | 2005 | PTV200902001L1K | therm-x2 Plan-V Hygiene | 70.1027 | 651.176 | 908.027 | 813.99 | 24 | WC / Personal / Damen | 01.00.019.2
Heizkörper | 905 | 102 | 1305 | PTV200901301L1K | therm-x2 Plan-V Hygiene | 42.4333 | 394.158 | 591.01 | 517.992 | 24 | WC / Personal / Herren | 01.00.020.2
Heizkörper | 905 | 102 | 905 | PTV200900901L1K | therm-x2 Plan-V Hygiene | 32.9908 | 306.448 | 409.858 | 371.995 | 24 | Vorraum / Sanitär | 01.00.020.1
Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 81.3061 | 755.243 | 1461.08 | 1169.99 | 24 | Umkleide / Personal / Herren | 01.00.020
Heizkörper | 905 | 157 | 1205 | PTV300901201L1K | therm-x2 Plan-V Hygiene | 50.2296 | 466.577 | 763.819 | 649.992 | 24 | Umkleide / Personal / Herren | 01.00.020
Heizkörper | 905 | 102 | 905 | PTV200900901L1K | therm-x2 Plan-V Hygiene | 30.1519 | 280.077 | 409.858 | 361.999 | 24 | Dusche / Personal | 01.00.021.3
Heizkörper | 905 | 157 | 705 | PTV300900701L1K | therm-x2 Plan-V Hygiene | 28.226 | 262.188 | 446.882 | 374.995 | 24 | WC / Personal | 01.00.021.2
Heizkörper | 905 | 157 | 1105 | PTV300901101L1K | therm-x2 Plan-V Hygiene | 46.9634 | 436.237 | 700.432 | 599.992 | 24 | Umkleide / Personal | 01.00.021
Heizkörper | 905 | 102 | 905 | PTV200900901L1K | therm-x2 Plan-V Hygiene | 35.8019 | 332.56 | 511.225 | 452.998 | 20 | Gebetsraum | 01.00.018
Heizkörper | 905 | 102 | 1105 | PTV200901101L1K | therm-x2 Plan-V Hygiene | 38.5989 | 358.541 | 624.203 | 532.994 | 20 | Putzraum / Entsorgung | 01.00.017
Heizkörper | 905 | 157 | 1805 | PTV300901801L1K | therm-x2 Plan-V Hygiene | 111.887 | 1039.3 | 1428.58 | 1319.98 | 20 | Lager | 01.00.010
Heizkörper | 905 | 102 | 2605 | PTV200902601L1K | therm-x2 Plan-V Hygiene | 79.7071 | 740.391 | 1471.54 | 1202.99 | 20 | Flur | 01.00.F03
Heizkörper | 905 | 157 | 1805 | PTV300901801L1K | therm-x2 Plan-V Hygiene | 84.4785 | 784.712 | 1428.58 | 1201.99 | 20 | Flur | 01.00.F03
Heizkörper | 905 | 157 | 2005 | PTV300902001L1K | therm-x2 Plan-V Hygiene | 99.9261 | 928.202 | 1586.87 | 1361.99 | 20 | Versorgungsraum / Wäsche | 01.00.014
Heizkörper | 905 | 157 | 1005 | PTV300901001L1K | therm-x2 Plan-V Hygiene | 51.6181 | 479.475 | 795.413 | 688.991 | 20 | Archiv | 01.00.012
Heizkörper | 905 | 157 | 1805 | PTV300901801L1K | therm-x2 Plan-V Hygiene | 96.6899 | 898.142 | 1428.58 | 1252.98 | 20 | Besprechungsraum | 01.00.013
Heizkörper | 905 | 157 | 705 | PTV300900701L1K | therm-x2 Plan-V Hygiene | 36.714 | 341.032 | 557.976 | 491.993 | 20 | Teeküche | 01.00.007
Heizkörper | 905 | 102 | 1205 | PTV200901201L1K | therm-x2 Plan-V Hygiene | 43.8314 | 407.145 | 545.722 | 494.993 | 24 | WC barrierefrei | 01.00.007.1
Heizkörper | 705 | 63 | 2005 | PTV100702001L1K | therm-x2 Plan-V Hygiene | 30.1661 | 280.209 | 512.517 | 430.995 | 20 | Dienstraum | 01.00.056
Heizkörper | 705 | 63 | 2005 | PTV100702001L1K | therm-x2 Plan-V Hygiene | 30.3833 | 282.227 | 512.517 | 431.994 | 20 | Dienstraum | 01.00.056
Heizkörper | 605 | 157 | 1605 | PTV300601601L1K | therm-x2 Plan-V Hygiene | 61.9727 | 575.657 | 909.025 | 799.991 | 20 | Dienstraum | 01.00.052
Heizkörper | 605 | 157 | 1305 | PTV300601301L1K | therm-x2 Plan-V Hygiene | 45.7613 | 425.072 | 739.114 | 631.992 | 20 | Dienstraum | 01.00.052
Heizkörper | 900 | 155 | 3000 | FK0330930 | therm-x2 Profil-K | 261.371 | 2427.85 | 5897.19 | 4778.99 | 10 | Müllsammelraum | 01.00.048
Heizkörper | 605 | 157 | 2305 |  | therm-x2 Plan-V Hygiene | 123.804 | 1150 |  | 1149.99 | 20 | Aufenthalt / Personal | 01.00.046
Heizkörper | 905 | 157 | 705 | PTV300900701L1K | therm-x2 Plan-V Hygiene | 29.8672 | 277.433 | 557.976 | 453.994 | 20 | Aufenthalt / Personal | 01.00.046
Heizkörper | 905 | 63 | 2605 |  | therm-x2 Plan-V Hygiene | 97.8589 | 909 |  | 908.99 | 15 | Flur | 01.00.F10
Heizkörper | 905 | 102 | 2005 | PTV200902001L1K | therm-x2 Plan-V Hygiene | 80.0416 | 743.498 | 1427.49 | 1212.99 | 15 | Flur | 01.00.F08
Heizkörper | 905 | 102 | 2005 |  | therm-x2 Plan-V Hygiene | 130.694 | 1214 |  | 1214 | 15 | Flur | 01.00.F08
2 x Heizkörper | 905 | 157 | 2605 |  | therm-x2 Plan-V Hygiene | 194.533 | 1807 |  | 1806.98 | 20 | Flur | 01.00.F05
2 x Heizkörper | 905 | 157 | 2605 | PTV300902601L1K | therm-x2 Plan-V Hygiene | 138.926 | 1290.47 | 2061.74 | 1805.98 | 20 | Flur | 01.00.F05
Heizkörper | 905 | 102 | 1805 | PTV200901801L1K | therm-x2 Plan-V Hygiene | 81.3709 | 755.846 | 1563.32 | 1329 | 10 | SPZ | 01.00.025
2 x Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 151.84 | 1410.43 | 2301.74 | 2043.98 | 15 | Lager | 01.00.035
2 x Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 151.552 | 1407.75 | 2301.74 | 2042.99 | 15 | Lager | 01.00.035
Heizkörper | 905 | 157 | 2305 | PTV300902301L1K | therm-x2 Plan-V Hygiene | 80.4142 | 746.958 | 1461.08 | 1164.99 | 24 | Umkleide / Personal / Herren | 01.00.020
Heizkörper | 905 | 157 | 1405 | PTV300901401L1K | therm-x2 Plan-V Hygiene | 78.6842 | 730.889 | 890.594 | 839.988 | 24 | Umkleideraum / Personal / Damen | 01.00.019
Heizkörper | 905 | 157 | 1105 | PTV300901101L1K | therm-x2 Plan-V Hygiene | 58.2556 | 541.13 | 700.432 | 649.996 | 24 | Umkleideraum / Personal / Damen | 01.00.019
Heizkörper | 505 | 157 | 1605 | PTV300501601L1K | therm-x2 Plan-V Hygiene | 66.4073 | 616.85 | 785.678 | 739.995 | 20 | Ruheraum | 01.00.005
Heizkörper | 905 | 157 | 505 | PTV300900501L1K | therm-x2 Plan-V Hygiene | 12.4411 | 115.564 | 320.107 | 218.998 | 24 | Umkleideraum / Personal / Damen | 01.00.019
Heizkörper | 705 | 157 | 1605 |  | therm-x2 Plan-V Hygiene | 92.799 | 862 |  | 861.991 | 20 | Dienstraum | 01.00.016
Heizkörper | 905 | 157 | 1205 | PTV300901201L1K | therm-x2 Plan-V Hygiene | 48.1966 | 447.693 | 953.704 | 772.992 | 20 | Dienstraum | 01.00.015
Heizkörper | 905 | 157 | 2005 |  | therm-x2 Plan-V Hygiene | 161.483 | 1500 |  | 1499.98 | 20 | Aufenthalt / Personal | 01.00.006

# IfcEnergyConversionDevice: Wasser-Wasser-WP
In: EG_Verwaltung_FFB
Description: Wasser-Wasser-WP
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Wasser-Wasser-WP; Info: 2200 kg; Room: Heizzentrale; Room No.: 01.00.023; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcEnergyConversionDevice: Zentrale (7)
In: EG_Verwaltung_FFB
Description: Zentrale

# IfcFlowController: Absperrarmatur Durchgang (21)
In: Wartung_FFB
Description: Absperrarmatur Durchgang
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Absperrarmatur Durchgang; Tech-Product item: Lokales Bauteil
Name | Tech-DN | Tech-Medium
3 x Absperrarmatur Durchgang | 200 | H_Vorlauf
5 x Absperrarmatur Durchgang | 125 | H_Vorlauf
4 x Absperrarmatur Durchgang | 125 | H_Ruecklauf
3 x Absperrarmatur Durchgang | 200 | H_Ruecklauf
Absperrarmatur Durchgang | 25 | H_Vorlauf
3 x Absperrarmatur Durchgang | 32 | H_Vorlauf
Absperrarmatur Durchgang | 150 | H_Vorlauf
Absperrarmatur Durchgang | 50 | H_Vorlauf

# IfcFlowController: Absperrklappe (37)
In: EG_Verwaltung_FFB
Description: Absperrklappe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Absperrklappe; Tech-Product item: Lokales Bauteil
Name | Tech-DN | Tech-Medium
7 x Absperrklappe | 125 | H_Vorlauf
7 x Absperrklappe | 125 | H_Ruecklauf
2 x Absperrklappe | 80 | H_Vorlauf
2 x Absperrklappe | 80 | H_Ruecklauf
3 x Absperrklappe | 150 | H_Vorlauf
Absperrklappe | 50 | H_Vorlauf
Absperrklappe | 40 | H_Vorlauf
Absperrklappe | 32 | H_Vorlauf
6 x Absperrklappe | 150 | H_Ruecklauf
Absperrklappe | 50 | H_Ruecklauf
Absperrklappe | 40 | H_Ruecklauf
Absperrklappe | 32 | H_Ruecklauf
Absperrklappe | 200 | H_Vorlauf
Absperrklappe | 200 | H_Ruecklauf
Absperrklappe | 65 | H_Vorlauf
Absperrklappe | 65 | H_Ruecklauf

# IfcFlowController: Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) (3)
In: Wartung_FFB
Description: Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h); Tech-Medium: H_Ruecklauf; Tech-Product item: Lokales Bauteil
Name | Tech-DN | dp component (mbar) (hPa) | dp throttle (mbar) (hPa) | dp (mbar) (Pa)
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 150 | 210 | 256.349 | 46634.9
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 125 | 210 |  | 21000
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 50 | 290 | 4.96781 | 29496.8

# IfcFlowController: Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h)
In: Wartung_FFB
Description: Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 25; dp component (mbar): 339 hPa; dp throttle (mbar): 8.40815 hPa; dp (mbar): 34740.8 Pa; Name: Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h); Tech-Medium: H_Ruecklauf; Tech-Product item: Lokales Bauteil

# IfcFlowController: Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) (3)
In: Wartung_FFB
Description: Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 32; Name: Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h); Tech-Medium: H_Ruecklauf; Tech-Product item: Lokales Bauteil
Name | dp component (mbar) (hPa) | dp throttle (mbar) (hPa) | dp (mbar) (Pa)
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 175 | 30.8675 | 20586.8
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 210 | 61.5536 | 27155.4
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 185 | 127.572 | 31257.2

# IfcFlowController: Kugelhahn (2)
In: EG_Verwaltung_FFB
Description: Kugelhahn
Pset_MEP - Tech-DN: 200; Geom-Outer diameter (mm): 340 mm; Geom-Length (mm): 600 mm; Tech-Insulation thickness (mm): 100 mm; Tech-PN: 16; Tech-Connection type (Inner thread=2, flange=3): 2; Name: Kugelhahn

# IfcFlowController: Pumpe (3)
In: EG_Verwaltung_FFB
Description: Pumpe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Pumpe; Tech-Product item: Lokales Bauteil
Name | Tech-DN | dp (mbar) (Pa) | Nominal pressure (mbar) (hPa) | Tech-Medium
Pumpe | 125 | 7447.45 | 74.4745 | H_Vorlauf
Pumpe | 80 | 4747.3 | 47.473 | H_Ruecklauf
Pumpe | 125 | 3930.58 | 39.3058 | H_Vorlauf

# IfcFlowController: Rücklaufverschraubung, Durchgang (74)
In: EG_Verwaltung_FFB
Description: Rücklaufverschraubung, Durchgang

# IfcFlowController: Schmutzfänger (3)
In: EG_Verwaltung_FFB
Description: Schmutzfänger
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Schmutzfänger; Tech-Medium: H_Ruecklauf; Tech-Product item: Lokales Bauteil
Name | Tech-DN
2 x Schmutzfänger | 125
Schmutzfänger | 80

# IfcFlowController: Thermostatventil Vorlauf, Durchgang (74)
In: EG_Verwaltung_FFB
Description: Thermostatventil Vorlauf, Durchgang

# IfcFlowController: Wärmemengenzähler (2)
In: EG_Verwaltung_FFB
Description: Wärmemengenzähler
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 125; Name: Wärmemengenzähler; Tech-Medium: H_Ruecklauf; Tech-Product item: Lokales Bauteil

# IfcFlowFitting: Bogen (4)
In: EG_Verwaltung_FFB
Description: Bogen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 90 rad; Tech-Material (ID): 1; Name: Bogen; Abbreviation: BGE
Name | Geom-Diameter (mm) (mm) = Geom-Radius (mm) (mm) | Tech-Medium
2 x Bogen | 200 | L_Zuluft
2 x Bogen | 250 | L_Abgas

# IfcFlowFitting: Bogen 90° 2M (8)
In: EG_Verwaltung_FFB
Description: Bogen 90° 2M
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 80; Name: Bogen 90° 2M; Info: DN 80; Tech-Medium: S_Gas; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Bogen 90° 2M; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/7f4fdd2f-c78a-4e3b-a70a-13e737bf9351; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -

# IfcFlowFitting: Kreuzstück (2)
In: EG_Verwaltung_FFB
Description: Kreuzstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 150; Tech-DN2: 50; Tech-DN3: 50; Tech-Insulation thickness (mm): 60 mm; Name: Kreuzstück; Info: DN 50; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Kreuzstück; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/7fe1223f-ba7a-4c27-aabd-95d73e4b7be2; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-Medium
Kreuzstück | H_Ruecklauf
Kreuzstück | H_Vorlauf

# IfcFlowFitting: Muffe (8)
In: EG_Verwaltung_FFB
Description: Muffe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN1: 80; Tech-DN2: 80; Name: Muffe; Info: DN 80; Tech-Medium: S_Gas; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Muffe; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/9221b3d4-96d1-4793-a0fa-ee6f20adb860; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -

# IfcFlowFitting: Reduzierung Bauart 1 (78)
Description: Reduzierung Bauart 1
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Reduzierung Bauart 1; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Reduzierung Bauart 1; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN1 | Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item
2 x Reduzierung Bauart 1 | Wartung_FFB | 200 | 150 | 100 | DN 200 - 150 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/edf78166-94f5-4dc1-adb3-0ec264e0dad6
4 x Reduzierung Bauart 1 | Wartung_FFB | 150 | 125 | 100 | DN 150 - 125 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ca01f289-d37a-4e18-aca3-085e3b174281
4 x Reduzierung Bauart 1 | Wartung_FFB | 150 | 125 | 100 | DN 150 - 125 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ca01f289-d37a-4e18-aca3-085e3b174281
2 x Reduzierung Bauart 1 | Wartung_FFB | 200 | 150 | 100 | DN 200 - 150 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/edf78166-94f5-4dc1-adb3-0ec264e0dad6
Reduzierung Bauart 1 | Wartung_FFB | 32 | 25 | 30 | DN 32 - 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/b985f0cc-a8ca-4605-b28e-ab6335d47e98
Reduzierung Bauart 1 | Wartung_FFB | 32 | 25 | 30 | DN 32 - 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/b985f0cc-a8ca-4605-b28e-ab6335d47e98
2 x Reduzierung Bauart 1 | Wartung_FFB | 40 | 32 | 40 | DN 40 - 32 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1e43701e-dc19-4264-b6a5-c752aa05eebc
2 x Reduzierung Bauart 1 | Wartung_FFB | 40 | 32 | 40 | DN 40 - 32 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1e43701e-dc19-4264-b6a5-c752aa05eebc
2 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 65 | 50 | 60 | DN 65 - 50 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/cd651ee7-3534-47a4-8ca7-228491e79844
Reduzierung Bauart 1 | EG_Verwaltung_FFB | 150 | 80 | 40 | DN 150 - 80 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/fffb1b41-7633-4efb-8e55-afcc68ad1a02
2 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 65 | 50 | 60 | DN 65 - 50 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/cd651ee7-3534-47a4-8ca7-228491e79844
Reduzierung Bauart 1 | EG_Verwaltung_FFB | 150 | 80 | 40 | DN 150 - 80 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/fffb1b41-7633-4efb-8e55-afcc68ad1a02
4 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 20 | 20 | DN 25 - 20 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5c67228e-f1fc-4b6a-a2cc-8103c4079007 | Pset_MEP - Tech-DN: 125
4 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 20 | 20 | DN 25 - 20 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5c67228e-f1fc-4b6a-a2cc-8103c4079007 | Pset_MEP - Tech-DN: 125
2 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 40 | 50 | DN 50 - 40 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7ef58a38-d5da-4295-8427-39e0d54cdaa6 | Pset_MEP - Tech-DN: 150
3 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 40 | 32 | 40 | DN 40 - 32 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1e43701e-dc19-4264-b6a5-c752aa05eebc
3 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 32 | 25 | 30 | DN 32 - 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/b985f0cc-a8ca-4605-b28e-ab6335d47e98
9 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 20 | 15 | 20 | DN 20 - 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/a4a79f14-aff1-4b65-9f3d-6c719c1e4822
9 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 20 | 15 | 20 | DN 20 - 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/a4a79f14-aff1-4b65-9f3d-6c719c1e4822
3 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 32 | 25 | 30 | DN 32 - 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/b985f0cc-a8ca-4605-b28e-ab6335d47e98
3 x Reduzierung Bauart 1 | EG_Verwaltung_FFB | 40 | 32 | 40 | DN 40 - 32 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1e43701e-dc19-4264-b6a5-c752aa05eebc
2 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 40 | 50 | DN 50 - 40 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7ef58a38-d5da-4295-8427-39e0d54cdaa6 | Pset_MEP - Tech-DN: 150
Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 25 | 30 | DN 50 - 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/40972182-0898-4910-85e0-e79690f2f3be | Pset_MEP - Tech-DN: 150
Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 25 | 30 | DN 50 - 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/40972182-0898-4910-85e0-e79690f2f3be | Pset_MEP - Tech-DN: 150
2 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 25 | 20 | DN 50 - 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/40972182-0898-4910-85e0-e79690f2f3be | Pset_MEP - Tech-DN: 150
3 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 15 | 20 | DN 25 - 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5b2ee4e7-e410-4449-a64e-b504cdea625a | Pset_MEP - Tech-DN: 125
2 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 25 | 20 | DN 50 - 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/40972182-0898-4910-85e0-e79690f2f3be | Pset_MEP - Tech-DN: 150
3 x Reduzierung Bauart 1 | EG_Verwaltung_FFB |  | 15 | 20 | DN 25 - 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5b2ee4e7-e410-4449-a64e-b504cdea625a | Pset_MEP - Tech-DN: 125

# IfcFlowFitting: Reduzierung Typ A, Konzentrisch (7)
In: EG_Verwaltung_FFB
Description: Reduzierung Typ A, Konzentrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Reduzierung Typ A, Konzentrisch; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Reduzierung Typ A, Konzentrisch; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN1 | Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item
Reduzierung Typ A, Konzentrisch | 150 | 65 | 70 | DN 150 - 65 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/06273de0-9849-4620-b834-7c8a38c33ea8
Reduzierung Typ A, Konzentrisch | 150 | 65 | 70 | DN 150 - 65 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/06273de0-9849-4620-b834-7c8a38c33ea8
Reduzierung Typ A, Konzentrisch | 80 | 32 | 40 | DN 80 - 32 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/87081008-fb1d-4aec-bf31-38d6e41079b5
Reduzierung Typ A, Konzentrisch | 80 | 32 | 40 | DN 80 - 32 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/87081008-fb1d-4aec-bf31-38d6e41079b5
Reduzierung Typ A, Konzentrisch |  | 20 | 20 | DN 50 - 20 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/485fbacd-1af0-41bc-8d89-27bb5b43009a | Pset_MEP - Tech-DN: 150
2 x Reduzierung Typ A, Konzentrisch |  | 20 | 20 | DN 50 - 20 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/485fbacd-1af0-41bc-8d89-27bb5b43009a | Pset_MEP - Tech-DN: 150

# IfcFlowFitting: Rohrbogen (7)
In: EG_Verwaltung_FFB
Description: Rohrbogen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohrbogen; Tech-Product item: Lokales Bauteil
Name | Tech-DN | Tech-Insulation thickness (mm) (mm) | Tech-Medium | Tech-Manufacturer | Tech-Order number = Tech-Standard Number
Rohrbogen | 25 | 40 | H_Ruecklauf | Pset_MEP - Room: Aufenthalt / Personal; Room No.: 01.00.006; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
2 x Rohrbogen | 200 | 100 | H_Ruecklauf | Generic | -
2 x Rohrbogen | 200 | 100 | H_Vorlauf | Generic | -
2 x Rohrbogen | 15 | 20 | H_Ruecklauf

# IfcFlowFitting: Rohrbogen Bauart 2 D 45° (12)
In: EG_Verwaltung_FFB
Description: Rohrbogen Bauart 2 D 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 40; Tech-Insulation thickness (mm): 50 mm; Name: Rohrbogen Bauart 2 D 45°; Info: DN 40; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Rohrbogen Bauart 2 D 45°; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/343fca4c-f7ef-4b04-9a72-a6e0c11506e6; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-Medium
6 x Rohrbogen Bauart 2 D 45° | H_Vorlauf
6 x Rohrbogen Bauart 2 D 45° | H_Ruecklauf

# IfcFlowFitting: Rohrbogen Bauart 2 D 90° (960)
Description: Rohrbogen Bauart 2 D 90°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohrbogen Bauart 2 D 90°; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Rohrbogen Bauart 2 D 90°; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item
8 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 200 | 100 | DN 200 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e9a86794-7e36-4276-8428-c796a907dca0
12 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 150 | 100 | DN 150 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f
12 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 150 | 100 | DN 150 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f
9 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 200 | 100 | DN 200 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e9a86794-7e36-4276-8428-c796a907dca0
14 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 32 | 40 | DN 32 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2021f5c1-aa68-4b5a-b1c3-66ade7d1495e
4 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 25 | 30 | DN 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c3ee1571-9e9d-421b-b51b-c803dadc47ff
4 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 25 | 30 | DN 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c3ee1571-9e9d-421b-b51b-c803dadc47ff
14 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 32 | 40 | DN 32 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2021f5c1-aa68-4b5a-b1c3-66ade7d1495e
4 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 125 | 100 | DN 125 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d27f4347-e7f4-4b5a-8106-d6ca333a5085
4 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 125 | 100 | DN 125 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d27f4347-e7f4-4b5a-8106-d6ca333a5085
3 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 40 | 50 | DN 40 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/671d1433-1831-489d-af4b-f1648d5e1d67
3 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 40 | 50 | DN 40 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/671d1433-1831-489d-af4b-f1648d5e1d67
4 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 50 | 60 | DN 50 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/3451f9d3-70de-4936-bec4-63f5455ec27f
4 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | 50 | 60 | DN 50 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/3451f9d3-70de-4936-bec4-63f5455ec27f
10 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 125 | 100 | DN 125 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d27f4347-e7f4-4b5a-8106-d6ca333a5085
13 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 125 | 100 | DN 125 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d27f4347-e7f4-4b5a-8106-d6ca333a5085
7 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 10 | 20 | DN 10 (ausserhalb der Norm) | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/16053945-13c4-4dfe-a8d1-2215f070f671
357 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 15 | 20 | DN 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/61198067-595c-4e88-9529-fb6118378d21
15 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 80 | 80 | DN 80 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/42f91b3b-88b6-477c-a90d-a54e259cab6b
14 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 80 | 80 | DN 80 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/42f91b3b-88b6-477c-a90d-a54e259cab6b
5 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 150 | 100 | DN 150 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f
20 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 50 | 60 | DN 50 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/3451f9d3-70de-4936-bec4-63f5455ec27f
6 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 40 | 50 | DN 40 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/671d1433-1831-489d-af4b-f1648d5e1d67
3 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 32 | 40 | DN 32 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2021f5c1-aa68-4b5a-b1c3-66ade7d1495e
6 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 150 | 100 | DN 150 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f
20 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 50 | 60 | DN 50 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/3451f9d3-70de-4936-bec4-63f5455ec27f
6 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 40 | 50 | DN 40 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/671d1433-1831-489d-af4b-f1648d5e1d67
3 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 32 | 40 | DN 32 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2021f5c1-aa68-4b5a-b1c3-66ade7d1495e
Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 200 | 100 | DN 200 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e9a86794-7e36-4276-8428-c796a907dca0
Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 200 | 100 | DN 200 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e9a86794-7e36-4276-8428-c796a907dca0
4 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 65 | 70 | DN 65 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/a072dff3-6ad8-43af-ab31-6e920771d11c
6 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 25 | 30 | DN 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c3ee1571-9e9d-421b-b51b-c803dadc47ff
332 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 15 | 20 | DN 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/61198067-595c-4e88-9529-fb6118378d21
6 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 25 | 30 | DN 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c3ee1571-9e9d-421b-b51b-c803dadc47ff
6 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 65 | 70 | DN 65 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/a072dff3-6ad8-43af-ab31-6e920771d11c
10 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 20 | 20 | DN 20 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/37e585a0-1c93-45ec-b472-7ed0d3657b37
10 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | 20 | 20 | DN 20 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/37e585a0-1c93-45ec-b472-7ed0d3657b37

# IfcFlowFitting: T-Stück (88)
Description: T-Stück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: T-Stück; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN1 | Tech-DN2 = Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item
2 x T-Stück | Wartung_FFB | 200 | 200 | 100 | DN 200 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fc242a3-5df7-44d7-a33f-6eeacb3131bf
2 x T-Stück | Wartung_FFB | 150 | 150 | 100 | DN 150 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5ab22024-ef4c-4578-8c8e-18d2136d5423
2 x T-Stück | Wartung_FFB | 150 | 150 | 100 | DN 150 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5ab22024-ef4c-4578-8c8e-18d2136d5423
2 x T-Stück | Wartung_FFB | 200 | 200 | 100 | DN 200 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fc242a3-5df7-44d7-a33f-6eeacb3131bf
T-Stück | Wartung_FFB | 32 | 32 | 40 | DN 32 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0866f1cd-a3b8-4164-b51c-da34d69254de
T-Stück | Wartung_FFB | 32 | 32 | 40 | DN 32 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0866f1cd-a3b8-4164-b51c-da34d69254de
T-Stück | Wartung_FFB | 40 | 40 | 50 | DN 40 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/959b1c0c-a8b9-4d64-aefa-41cf5672e043
T-Stück | Wartung_FFB | 40 | 40 | 50 | DN 40 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/959b1c0c-a8b9-4d64-aefa-41cf5672e043
2 x T-Stück | EG_Verwaltung_FFB | 150 | 150 | 100 | DN 150 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5ab22024-ef4c-4578-8c8e-18d2136d5423
2 x T-Stück | EG_Verwaltung_FFB | 150 | 150 | 100 | DN 150 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/5ab22024-ef4c-4578-8c8e-18d2136d5423
T-Stück | EG_Verwaltung_FFB | 80 | 80 | 80 | DN 80 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c4752068-6396-4dec-b792-6f743ae15034
T-Stück | EG_Verwaltung_FFB | 80 | 80 | 80 | DN 80 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c4752068-6396-4dec-b792-6f743ae15034
4 x T-Stück | EG_Verwaltung_FFB |  | 50 | 60 | DN 50 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ad1ee5c6-1705-4c7e-bfd6-cbe1207cda6b | Pset_MEP - Tech-DN: 150
T-Stück | EG_Verwaltung_FFB |  | 25 | 30 | DN 25 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0ed4da3f-7e43-4c74-853e-7ba44dc6f801 | Pset_MEP - Tech-DN: 125
T-Stück | EG_Verwaltung_FFB | 20 | 20 | 20 | DN 20 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ae2fcdb6-ec92-4348-abf8-76552d003b96
T-Stück | EG_Verwaltung_FFB | 20 | 20 | 20 | DN 20 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ae2fcdb6-ec92-4348-abf8-76552d003b96
T-Stück | EG_Verwaltung_FFB |  | 25 | 30 | DN 25 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/0ed4da3f-7e43-4c74-853e-7ba44dc6f801 | Pset_MEP - Tech-DN: 125
4 x T-Stück | EG_Verwaltung_FFB |  | 50 | 60 | DN 50 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ad1ee5c6-1705-4c7e-bfd6-cbe1207cda6b | Pset_MEP - Tech-DN: 150
28 x T-Stück | EG_Verwaltung_FFB | 15 | 15 | 20 | DN 15 (ausserhalb der Norm) | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1e47d7dd-babf-40d0-9e54-4e9e27eb8a5d
28 x T-Stück | EG_Verwaltung_FFB | 15 | 15 | 20 | DN 15 (ausserhalb der Norm) | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/1e47d7dd-babf-40d0-9e54-4e9e27eb8a5d
T-Stück | EG_Verwaltung_FFB | 40 | 40 | 50 | DN 40 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/959b1c0c-a8b9-4d64-aefa-41cf5672e043
T-Stück | EG_Verwaltung_FFB | 40 | 40 | 50 | DN 40 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/959b1c0c-a8b9-4d64-aefa-41cf5672e043

# IfcFlowFitting: T-Stück, reduziert (96)
In: EG_Verwaltung_FFB
Description: T-Stück, reduziert
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: T-Stück, reduziert; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück, reduziert; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN1 | Tech-DN2 | Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item
T-Stück, reduziert | 150 | 150 | 125 | 100 | DN 150 - 125 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/24bed32a-2681-4765-b3f8-607d620dd634
T-Stück, reduziert | 65 | 65 | 40 | 70 | DN 65 - 40 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ac03dc20-7583-4eb7-bf50-993c575565d1
T-Stück, reduziert | 150 | 150 | 125 | 100 | DN 150 - 125 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/24bed32a-2681-4765-b3f8-607d620dd634
T-Stück, reduziert | 65 | 65 | 40 | 70 | DN 65 - 40 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/ac03dc20-7583-4eb7-bf50-993c575565d1
T-Stück, reduziert | 65 | 65 | 50 | 70 | DN 65 - 50 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/94504997-6625-4d47-8920-fef4906db65b
T-Stück, reduziert | 65 | 65 | 50 | 70 | DN 65 - 50 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/94504997-6625-4d47-8920-fef4906db65b
12 x T-Stück, reduziert | 40 | 40 | 15 | 50 | DN 40 - 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bec2644a-f621-4347-bf71-3c64ea15d442
10 x T-Stück, reduziert | 32 | 32 | 15 | 40 | DN 32 - 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/521e1841-049b-4073-ba41-59ad2b1be407
T-Stück, reduziert | 32 | 32 | 20 | 40 | DN 32 - 20 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/62225c86-da17-46d5-a767-30ef908192de
9 x T-Stück, reduziert |  | 25 | 15 | 30 | DN 25 - 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/88521c17-a4c6-4a88-99ef-ac62b38474fe | Pset_MEP - Tech-DN: 125
13 x T-Stück, reduziert | 20 | 20 | 15 | 20 | DN 20 - 15 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/6e9bcd33-62de-45e7-af35-ad966fb577d1
13 x T-Stück, reduziert | 20 | 20 | 15 | 20 | DN 20 - 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/6e9bcd33-62de-45e7-af35-ad966fb577d1
9 x T-Stück, reduziert |  | 25 | 15 | 30 | DN 25 - 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/88521c17-a4c6-4a88-99ef-ac62b38474fe | Pset_MEP - Tech-DN: 125
10 x T-Stück, reduziert | 32 | 32 | 15 | 40 | DN 32 - 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/521e1841-049b-4073-ba41-59ad2b1be407
T-Stück, reduziert | 32 | 32 | 20 | 40 | DN 32 - 20 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/62225c86-da17-46d5-a767-30ef908192de
12 x T-Stück, reduziert | 40 | 40 | 15 | 50 | DN 40 - 15 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bec2644a-f621-4347-bf71-3c64ea15d442

# IfcFlowFitting: Übergangsstück (3)
In: EG_Verwaltung_FFB
Description: Übergangsstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 150; Tech-DN2: 20; Tech-Insulation thickness (mm): 20 mm; Name: Übergangsstück; Tech-Product item: Lokales Bauteil
Name | Tech-Medium
Übergangsstück | H_Ruecklauf
2 x Übergangsstück | H_Vorlauf

# IfcFlowMovingDevice: SLK Wandgerät (10)
In: EG_Verwaltung_FFB
Description: SLK Wandgerät
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: SLK Wandgerät
Name | Info
4 x SLK Wandgerät | 1,6 kW
SLK Wandgerät | 1,2 kW
2 x SLK Wandgerät | 1,1 kW
2 x SLK Wandgerät | 1,4 kW
SLK Wandgerät | 1,5 kW

# IfcFlowSegment: Abgasrohr Kessel (2)
Description: Abgasrohr Kessel
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Diameter (mm): 250 mm; Tech-Medium: L_Abgas; Tech-Material (ID): 1; Name: Abgasrohr Kessel; Abbreviation: R-R; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Geom-Length (mm) (mm) | Floor | Floor No.
Abgasrohr Kessel | Wartung_FFB | 5060 | Wartung_FFB | 2
Abgasrohr Kessel | EG_Verwaltung_FFB | 3235 | EG_Verwaltung_FFB | 0 | Pset_MEP - Room: Heizzentrale; Room No.: 01.00.023

# IfcFlowSegment: Kupferrohr DIN EN 1057 (16)
In: EG_Verwaltung_FFB
Description: Kupferrohr DIN EN 1057
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 80; Tech-Outside diameter (mm): 88.9 mm; Tech-Inside diameter (mm): 84.9 mm; Name: Kupferrohr DIN EN 1057; Info: 88.9 x 2; Tech-Medium: S_Gas; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Kupferrohr DIN EN 1057; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/fa56e9e6-e580-4b6d-859c-b2eeced1bb1d; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Geom-Length (mm) (m)
Kupferrohr DIN EN 1057 | 3212
8 x Kupferrohr DIN EN 1057 | 5000
Kupferrohr DIN EN 1057 | 571.383
Kupferrohr DIN EN 1057 | 4991.01
Kupferrohr DIN EN 1057 | 3401.67
Kupferrohr DIN EN 1057 | 1018.54
Kupferrohr DIN EN 1057 | 2098.27
Kupferrohr DIN EN 1057 | 432.235
Kupferrohr DIN EN 1057 | 2712

# IfcFlowSegment: Luftzufuhr Kessel (2)
Description: Luftzufuhr Kessel
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Diameter (mm): 200 mm; Tech-Medium: L_Zuluft; Tech-Material (ID): 1; Name: Luftzufuhr Kessel; Abbreviation: R-R; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Geom-Length (mm) (mm) | Floor | Floor No.
Luftzufuhr Kessel | Wartung_FFB | 5060 | Wartung_FFB | 2
Luftzufuhr Kessel | EG_Verwaltung_FFB | 3235 | EG_Verwaltung_FFB | 0 | Pset_MEP - Room: Heizzentrale; Room No.: 01.00.023

# IfcFlowSegment: Rohr (4)
In: EG_Verwaltung_FFB
Description: Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohr; Tech-Product item: Lokales Bauteil
Name | Geom-Length (mm) (m) | Tech-DN = Tech-Outside diameter (mm) (mm) = Tech-Inside diameter (mm) (mm) | Tech-Medium | Tech-Insulation thickness (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s)
Rohr | 2.5 | 80 | S_Gas
Rohr | 8.5 | 15 | H_Ruecklauf | 20 | 46.9634 | 47.4531 | 0.0468378 | 0.0647471
Rohr | 2.5 | 20 | H_Ruecklauf | 20 | 325.227 | 328.619 | 0.480641 | 0.24682
Rohr | 5.65574 | 15 | H_Vorlauf | 20 | 151.552 | 153.133 | 0.526101 | 0.208941

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Description: Rohr DIN EN 10220
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohr DIN EN 10220; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Rohr DIN EN 10220; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | Wartung_FFB | 1047 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3001.65 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
6 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
