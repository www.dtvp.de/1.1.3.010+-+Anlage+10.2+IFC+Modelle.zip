Properties of the parts of a building model (IFC2X3), part 4 of 7

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 388.879 | 20 | 15 | 21.3 | 17.3 | 105.341 | 106.44 | 0.277366 | 0.145231 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2456.45 | 20 | 15 | 21.3 | 17.3 | 186.647 | 188.594 | 0.762113 | 0.257325 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1243.76 | 20 | 15 | 21.3 | 17.3 | 186.647 | 188.594 | 0.762113 | 0.257325 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4521.68 | 20 | 15 | 21.3 | 17.3 | 186.647 | 188.594 | 0.762113 | 0.257325 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 393.5 | 20 | 15 | 21.3 | 17.3 | 242.1 | 244.624 | 1.21583 | 0.333776 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5180.61 | 20 | 15 | 21.3 | 17.3 | 242.1 | 244.624 | 1.21583 | 0.333776 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1385.02 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1045.91 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3315 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 120.782 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 140.829 | 20 | 15 | 21.3 | 17.3 | 38.5989 | 39.0014 | 0.0384957 | 0.0532153 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 182.351 | 20 | 15 | 21.3 | 17.3 | 38.5989 | 39.0014 | 0.0384957 | 0.0532153 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 131.048 | 20 | 15 | 21.3 | 17.3 | 38.5989 | 39.0014 | 0.0384957 | 0.0532153 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 30.0928 | 20 | 15 | 21.3 | 17.3 | 38.5989 | 39.0014 | 0.0384957 | 0.0532153 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1415.02 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1216.13 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2515 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 43.9769 | 20 | 15 | 21.3 | 17.3 | 74.4009 | 75.1767 | 0.151636 | 0.102574 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 393.5 | 20 | 15 | 21.3 | 17.3 | 242.1 | 244.624 | 1.21583 | 0.333776 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4792.61 | 20 | 15 | 21.3 | 17.3 | 242.1 | 244.624 | 1.21583 | 0.333776 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 737.425 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2360 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 159.17 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.465 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 927.206 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3165 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.952 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 323.465 | 20 | 15 | 21.3 | 17.3 | 50.2296 | 50.7533 | 0.0500953 | 0.0692501 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 737.425 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2365 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 150.33 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 54.2962 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 927.206 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3165 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 140.548 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 226.796 | 20 | 15 | 21.3 | 17.3 | 32.9908 | 33.3348 | 0.0329026 | 0.0454835 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 307.5 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2541.21 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 475.749 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2160 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 155.204 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 117.041 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 307.5 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2241.21 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 365.531 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2965 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 164.985 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 272.041 | 20 | 15 | 21.3 | 17.3 | 84.4785 | 85.3594 | 0.188891 | 0.116468 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 135.952 | 20 | 15 | 21.3 | 17.3 | 35.8019 | 36.1753 | 0.0357062 | 0.0493592 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 30.0928 | 20 | 15 | 21.3 | 17.3 | 35.8019 | 36.1753 | 0.0357062 | 0.0493592 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 126.171 | 20 | 15 | 21.3 | 17.3 | 35.8019 | 36.1753 | 0.0357062 | 0.0493592 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 182.351 | 20 | 15 | 21.3 | 17.3 | 35.8019 | 36.1753 | 0.0357062 | 0.0493592 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85.7691 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 175.224 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 94.0148 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3465 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 663.548 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 247.5 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 50.7691 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 175.224 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2660 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 395.548 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 247.5 | 20 | 15 | 21.3 | 17.3 | 80.4142 | 81.2527 | 0.17343 | 0.110865 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 547.5 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 539.51 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3165 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 169.521 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 220.868 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 547.5 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 713.291 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2360 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 179.303 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 65.8677 | 20 | 15 | 21.3 | 17.3 | 81.3061 | 82.1539 | 0.176773 | 0.112094 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 247.5 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3896.38 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3465 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 159.409 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 248.544 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 247.5 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3967.9 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2665 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 149.627 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 76.0443 | 20 | 15 | 21.3 | 17.3 | 28.226 | 28.5203 | 0.0281505 | 0.0389143 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 277.891 | 20 | 15 | 21.3 | 17.3 | 46.9634 | 47.4531 | 0.0468378 | 0.0647471 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 446.5 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3197.95 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 279.33 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2310 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 159.17 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 74.4606 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 446.5 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3585.95 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 389.548 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3115 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.952 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 109.461 | 20 | 15 | 21.3 | 17.3 | 58.9557 | 59.5705 | 0.0587981 | 0.0812806 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 446.5 | 20 | 15 | 21.3 | 17.3 | 255.428 | 258.091 | 1.33943 | 0.352151 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 699.592 | 20 | 15 | 21.3 | 17.3 | 255.428 | 258.091 | 1.33943 | 0.352151 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 657.391 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1965 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 66.3199 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 152.5 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 257.5 | 20 | 15 | 21.3 | 17.3 | 79.0134 | 79.8373 | 0.168238 | 0.108934 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 304.327 | 20 | 15 | 21.3 | 17.3 | 79.0134 | 79.8373 | 0.168238 | 0.108934 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 257.5 | 20 | 15 | 21.3 | 17.3 | 79.0134 | 79.8373 | 0.168238 | 0.108934 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 349.108 | 20 | 15 | 21.3 | 17.3 | 79.0134 | 79.8373 | 0.168238 | 0.108934 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 107.5 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 547.172 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2765 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 186.32 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.5 | 20 | 15 | 21.3 | 17.3 | 142.892 | 144.382 | 0.474062 | 0.197001 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 446.5 | 20 | 15 | 21.3 | 17.3 | 255.428 | 258.091 | 1.33943 | 0.352151 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1087.59 | 20 | 15 | 21.3 | 17.3 | 255.428 | 258.091 | 1.33943 | 0.352151 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 660.703 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 547.172 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3015 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 249.477 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 57.5 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 257.5 | 20 | 15 | 21.3 | 17.3 | 70.1027 | 70.8337 | 0.136856 | 0.0966487 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 309.766 | 20 | 15 | 21.3 | 17.3 | 70.1027 | 70.8337 | 0.136856 | 0.0966487 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 257.5 | 20 | 15 | 21.3 | 17.3 | 70.1027 | 70.8337 | 0.136856 | 0.0966487 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 264.985 | 20 | 15 | 21.3 | 17.3 | 70.1027 | 70.8337 | 0.136856 | 0.0966487 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 900.703 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 657.391 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 129.477 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2302.5 | 20 | 15 | 21.3 | 17.3 | 112.536 | 113.709 | 0.311363 | 0.15515 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 215.5 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3708.4 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 537.391 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2960 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 158.399 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 38.7502 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 215.5 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4090.63 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 667.172 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3765 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 79.2317 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.18 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 73.7502 | 20 | 15 | 21.3 | 17.3 | 79.3075 | 80.1345 | 0.169322 | 0.109339 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 715.5 | 20 | 15 | 21.3 | 17.3 | 125.415 | 126.723 | 0.37661 | 0.172907 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4903.65 | 20 | 15 | 21.3 | 17.3 | 125.415 | 126.723 | 0.37661 | 0.172907 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2717.65 | 20 | 15 | 21.3 | 17.3 | 46.7312 | 47.2185 | 0.0466063 | 0.064427 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.5 | 20 | 15 | 21.3 | 17.3 | 46.7312 | 47.2185 | 0.0466063 | 0.064427 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 900.301 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2260 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 141.97 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 109.974 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 114.689 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1030.08 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3065 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 299.377 | 20 | 15 | 21.3 | 17.3 | 34.2901 | 34.6477 | 0.0341985 | 0.0472749 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2722.9 | 20 | 15 | 21.3 | 17.3 | 46.7312 | 47.2185 | 0.0466063 | 0.064427 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.5 | 20 | 15 | 21.3 | 17.3 | 46.7312 | 47.2185 | 0.0466063 | 0.064427 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 715.5 | 20 | 15 | 21.3 | 17.3 | 125.415 | 126.723 | 0.37661 | 0.172907 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5309.88 | 20 | 15 | 21.3 | 17.3 | 125.415 | 126.723 | 0.37661 | 0.172907 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.5 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1047.36 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3065 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 103.228 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 175.903 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 108.954 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 73.9544 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 167.058 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2260 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 918.514 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.5 | 20 | 15 | 21.3 | 17.3 | 78.6842 | 79.5047 | 0.167028 | 0.10848 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 878.972 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 140.697 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3065 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 65 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 168.697 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 118.428 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 32.5 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 32.5 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 83.4278 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 172.653 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2260 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 288.127 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1098.97 | 20 | 15 | 21.3 | 17.3 | 12.4411 | 12.5708 | 0.0124078 | 0.0171522 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 92.1318 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 169.088 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2760 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 644.127 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 179.113 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 568.136 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 873.774 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 86.0238 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 183.102 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 127.132 | 20 | 15 | 21.3 | 17.3 | 58.2556 | 58.8631 | 0.0580999 | 0.0803154 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 967.219 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2760 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 191.665 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 78.5874 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 610.202 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 192.657 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 113.587 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 46.178 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 191.015 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 966.57 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 81.178 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 200.797 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 618.342 | 20 | 15 | 21.3 | 17.3 | 129.778 | 131.131 | 0.399977 | 0.178921 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 82.5 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 136.243 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2760 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 403.562 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 148.069 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 237.5 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 142.296 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 289.615 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 386.079 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 79.7071 | 80.5383 | 0.170801 | 0.10989 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1980.55 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 271.764 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2960 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 100.004 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 521.536 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1502.54 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 166.867 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 220.004 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 571.634 | 20 | 15 | 21.3 | 17.3 | 36.9103 | 37.2952 | 0.0368116 | 0.0508872 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5294.35 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2760 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 160.093 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 106.396 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5642.17 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3565 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 170.281 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 141.396 | 20 | 15 | 21.3 | 17.3 | 99.9261 | 100.968 | 0.25295 | 0.137765 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1900.34 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 364.403 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2557.5 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 132.717 | 20 | 15 | 21.3 | 17.3 | 155.927 | 157.553 | 0.553325 | 0.214972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 352.5 | 20 | 15 | 21.3 | 17.3 | 155.927 | 157.553 | 0.553325 | 0.214972 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 274.02 | 20 | 15 | 21.3 | 17.3 | 53.9745 | 54.5373 | 0.0538302 | 0.0744131 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 182.5 | 20 | 15 | 21.3 | 17.3 | 53.9745 | 54.5373 | 0.0538302 | 0.0744131 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 349.415 | 20 | 15 | 21.3 | 17.3 | 53.9745 | 54.5373 | 0.0538302 | 0.0744131 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 15.6725 | 20 | 15 | 21.3 | 17.3 | 53.9745 | 54.5373 | 0.0538302 | 0.0744131 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 415.5 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1422.33 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 238.402 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3557.5 | 20 | 15 | 21.3 | 17.3 | 248.726 | 251.319 | 1.27658 | 0.342911 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 67.5 | 20 | 15 | 21.3 | 17.3 | 92.799 | 93.7667 | 0.222359 | 0.127939 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
