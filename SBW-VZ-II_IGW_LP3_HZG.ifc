Properties of the parts of a building model (IFC2X3), part 3 of 7

# IfcFlowSegment: Rohr DIN EN 10220 (1596)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 768 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 379 | 40 | 32 | 42.4 | 37.2 | 1906.18 | 1926.06 |  |  | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3632 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 77.2823 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5532 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 77.2823 | 100 | 200 | 219.1 | 206.5 | 180926 | 182812 | 0.854832 | 1.51626 | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 591.171 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 845.158 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1778.99 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 864.29 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 830.09 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1516.53 | 100 | 200 | 219.1 | 206.5 |  |  |  |  | DN 200 | 219.1 x 6.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1069.42 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1248 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1703.48 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1878 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 287.775 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3426.07 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 318 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2376.15 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2838 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3128 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 60.7456 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2838 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3128 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 410.746 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1049.42 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1883.42 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2378 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 437.831 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3446.07 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 318 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2776.15 | 80 | 80 | 88.9 | 82.5 | 12927.4 | 13029 | 0.636513 | 0.704081 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3118 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3118 | 80 | 80 | 88.9 | 82.5 | 6463.71 | 6514.52 | 0.177063 | 0.352041 | DN 80 | 88.9 x 3.2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/e66d175e-cdd2-4080-b2a3-b87c83f6249e
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 397 | 60 | 50 | 60.3 | 54.5 | 4777.8 | 4827.62 | 0.796605 | 0.605553 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4381.75 | 20 | 20 | 26.9 | 22.3 | 606.785 | 613.113 | 1.48665 | 0.460499 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3998.75 | 20 | 20 | 26.9 | 22.3 | 606.785 | 613.113 | 1.48665 | 0.460499 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 397 | 60 | 50 | 60.3 | 54.5 | 4777.8 | 4827.62 | 0.796605 | 0.605553 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 731.993 | 60 | 50 | 60.3 | 54.5 | 3745.65 | 3784.71 | 0.507555 | 0.474734 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4561.91 | 60 | 50 | 60.3 | 54.5 | 3686.69 | 3725.13 | 0.492921 | 0.467262 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3431.26 | 3467.04 | 1.39721 | 0.698456 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 716.586 | 50 | 40 | 48.3 | 43.1 | 3431.26 | 3467.04 | 1.39721 | 0.698456 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3351.96 | 3386.91 | 1.33757 | 0.682312 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 230.464 | 50 | 40 | 48.3 | 43.1 | 3351.96 | 3386.91 | 1.33757 | 0.682312 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1355.22 | 50 | 40 | 48.3 | 43.1 | 3226.54 | 3260.19 | 1.24581 | 0.656783 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1791.23 | 50 | 40 | 48.3 | 43.1 | 3038.51 | 3070.19 | 1.11413 | 0.618508 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3903 | 50 | 40 | 48.3 | 43.1 | 2908.73 | 2939.06 | 1.02737 | 0.592091 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1904.57 | 50 | 40 | 48.3 | 43.1 | 2829.02 | 2858.52 | 0.975763 | 0.575866 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2329.09 | 50 | 40 | 48.3 | 43.1 | 2792.11 | 2821.23 | 0.952296 | 0.568352 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1471.96 | 50 | 40 | 48.3 | 43.1 | 2692.19 | 2720.26 | 0.890137 | 0.548012 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5491.6 | 50 | 40 | 48.3 | 43.1 | 2443.46 | 2468.94 | 0.744151 | 0.497382 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 157.805 | 40 | 32 | 42.4 | 37.2 | 2265.53 | 2289.16 | 1.37329 | 0.62471 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1163.28 | 40 | 32 | 42.4 | 37.2 | 2168.84 | 2191.46 | 1.26647 | 0.598048 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4839.08 | 40 | 32 | 42.4 | 37.2 | 1992.54 | 2013.32 | 1.08241 | 0.549433 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 40 | 32 | 42.4 | 37.2 | 1531.76 | 1547.73 | 0.666975 | 0.422376 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 273.269 | 40 | 32 | 42.4 | 37.2 | 1531.76 | 1547.73 | 0.666975 | 0.422376 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5059.82 | 40 | 32 | 42.4 | 37.2 | 1371.98 | 1386.29 | 0.545249 | 0.378316 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5378.74 | 40 | 32 | 42.4 | 37.2 | 1178.63 | 1190.92 | 0.413511 | 0.325002 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 557.021 | 30 | 25 | 33.7 | 28.5 | 934.58 | 944.326 | 1.05538 | 0.44813 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5784.21 | 30 | 25 | 33.7 | 28.5 | 779.23 | 787.355 | 0.757154 | 0.37364 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4293.51 | 30 | 25 | 33.7 | 28.5 | 622.176 | 628.664 | 0.503395 | 0.298333 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5076.67 | 20 | 20 | 26.9 | 22.3 | 531.529 | 537.072 | 1.16715 | 0.403386 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1412.84 | 20 | 20 | 26.9 | 22.3 | 440.883 | 445.48 | 0.831062 | 0.334593 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 242.997 | 245.531 | 1.22397 | 0.335013 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 911.937 | 20 | 15 | 21.3 | 17.3 | 242.997 | 245.531 | 1.22397 | 0.335013 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 242.997 | 245.531 | 1.22397 | 0.335013 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 911.937 | 20 | 15 | 21.3 | 17.3 | 242.997 | 245.531 | 1.22397 | 0.335013 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1652.84 | 20 | 20 | 26.9 | 22.3 | 440.883 | 445.48 | 0.831062 | 0.334593 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4836.67 | 20 | 20 | 26.9 | 22.3 | 531.529 | 537.072 | 1.16715 | 0.403386 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4533.51 | 30 | 25 | 33.7 | 28.5 | 622.176 | 628.664 | 0.503395 | 0.298333 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5784.21 | 30 | 25 | 33.7 | 28.5 | 779.23 | 787.355 | 0.757154 | 0.37364 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 587.021 | 30 | 25 | 33.7 | 28.5 | 934.58 | 944.326 | 1.05538 | 0.44813 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5348.74 | 40 | 32 | 42.4 | 37.2 | 1178.63 | 1190.92 | 0.413511 | 0.325002 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5059.82 | 40 | 32 | 42.4 | 37.2 | 1371.98 | 1386.29 | 0.545249 | 0.378316 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 40 | 32 | 42.4 | 37.2 | 1531.76 | 1547.73 | 0.666975 | 0.422376 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 273.269 | 40 | 32 | 42.4 | 37.2 | 1531.76 | 1547.73 | 0.666975 | 0.422376 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5079.08 | 40 | 32 | 42.4 | 37.2 | 1992.54 | 2013.32 | 1.08241 | 0.549433 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 923.293 | 40 | 32 | 42.4 | 37.2 | 2168.84 | 2191.46 | 1.26647 | 0.598048 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 397.795 | 40 | 32 | 42.4 | 37.2 | 2265.53 | 2289.16 | 1.37329 | 0.62471 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5491.6 | 50 | 40 | 48.3 | 43.1 | 2443.46 | 2468.94 | 0.744151 | 0.497382 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1231.96 | 50 | 40 | 48.3 | 43.1 | 2692.19 | 2720.26 | 0.890137 | 0.548012 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2329.09 | 50 | 40 | 48.3 | 43.1 | 2792.11 | 2821.23 | 0.952296 | 0.568352 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1904.57 | 50 | 40 | 48.3 | 43.1 | 2829.02 | 2858.52 | 0.975763 | 0.575866 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3903 | 50 | 40 | 48.3 | 43.1 | 2908.73 | 2939.06 | 1.02737 | 0.592091 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2031.23 | 50 | 40 | 48.3 | 43.1 | 3038.51 | 3070.19 | 1.11413 | 0.618508 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1259.58 | 50 | 40 | 48.3 | 43.1 | 3226.54 | 3260.19 | 1.24581 | 0.656783 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3351.96 | 3386.91 | 1.33757 | 0.682312 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 230.464 | 50 | 40 | 48.3 | 43.1 | 3351.96 | 3386.91 | 1.33757 | 0.682312 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3431.26 | 3467.04 | 1.39721 | 0.698456 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 476.586 | 50 | 40 | 48.3 | 43.1 | 3431.26 | 3467.04 | 1.39721 | 0.698456 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4801.91 | 60 | 50 | 60.3 | 54.5 | 3686.69 | 3725.13 | 0.492921 | 0.467262 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 829.993 | 60 | 50 | 60.3 | 54.5 | 3745.65 | 3784.71 | 0.507555 | 0.474734 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4329.76 | 20 | 20 | 26.9 | 22.3 | 509.161 | 514.471 | 1.07924 | 0.38641 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3337.46 | 20 | 15 | 21.3 | 17.3 | 267.061 | 269.846 | 1.45189 | 0.36819 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3286.47 | 20 | 15 | 21.3 | 17.3 | 267.061 | 269.846 | 1.45189 | 0.36819 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4727.76 | 20 | 20 | 26.9 | 22.3 | 509.161 | 514.471 | 1.07924 | 0.38641 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2875.23 | 20 | 15 | 21.3 | 17.3 | 191.87 | 193.871 | 0.800651 | 0.264526 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 500.98 | 20 | 15 | 21.3 | 17.3 | 158.879 | 160.536 | 0.572057 | 0.219043 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 740.98 | 20 | 15 | 21.3 | 17.3 | 158.879 | 160.536 | 0.572057 | 0.219043 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2875.23 | 20 | 15 | 21.3 | 17.3 | 191.87 | 193.871 | 0.800651 | 0.264526 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 270.173 | 20 | 15 | 21.3 | 17.3 | 46.9634 | 47.4531 | 0.0468378 | 0.0647471 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 282.519 | 20 | 15 | 21.3 | 17.3 | 42.4333 | 42.8758 | 0.0423199 | 0.0585016 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 307.737 | 20 | 15 | 21.3 | 17.3 | 42.4333 | 42.8758 | 0.0423199 | 0.0585016 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 364.363 | 20 | 15 | 21.3 | 17.3 | 63.8786 | 64.5447 | 0.116646 | 0.0880676 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 339.144 | 20 | 15 | 21.3 | 17.3 | 63.8786 | 64.5447 | 0.116646 | 0.0880676 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 176.904 | 20 | 15 | 21.3 | 17.3 | 92.799 | 93.7667 | 0.222359 | 0.127939 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 234.343 | 20 | 15 | 21.3 | 17.3 | 101.952 | 103.015 | 0.261967 | 0.140559 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 205.344 | 20 | 15 | 21.3 | 17.3 | 101.952 | 103.015 | 0.261967 | 0.140559 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 239.542 | 20 | 15 | 21.3 | 17.3 | 53.9745 | 54.5373 | 0.0538302 | 0.0744131 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 291.734 | 20 | 15 | 21.3 | 17.3 | 74.1319 | 74.9049 | 0.150692 | 0.102204 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 241.963 | 20 | 15 | 21.3 | 17.3 | 37.0855 | 37.4722 | 0.0369864 | 0.0511288 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 698.037 | 20 | 15 | 21.3 | 17.3 | 122.697 | 123.976 | 0.362372 | 0.169159 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 647.94 | 20 | 15 | 21.3 | 17.3 | 122.697 | 123.976 | 0.362372 | 0.169159 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 266.62 | 20 | 15 | 21.3 | 17.3 | 73.8347 | 74.6046 | 0.149651 | 0.101794 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 559.531 | 20 | 15 | 21.3 | 17.3 | 119.514 | 120.76 | 0.346017 | 0.164771 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5194.16 | 20 | 15 | 21.3 | 17.3 | 163.505 | 165.21 | 0.601973 | 0.225419 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5194.16 | 20 | 15 | 21.3 | 17.3 | 163.505 | 165.21 | 0.601973 | 0.225419 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 673.037 | 20 | 15 | 21.3 | 17.3 | 85.1564 | 86.0444 | 0.191526 | 0.117403 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 377.132 | 20 | 15 | 21.3 | 17.3 | 70.1942 | 70.9261 | 0.137164 | 0.0967747 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 402.869 | 20 | 15 | 21.3 | 17.3 | 66.4073 | 67.0998 | 0.124686 | 0.0915539 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 623.529 | 20 | 15 | 21.3 | 17.3 | 90.6464 | 91.5917 | 0.213468 | 0.124972 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
3 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3292.03 | 3326.36 | 1.29333 | 0.670114 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2622.92 | 50 | 40 | 48.3 | 43.1 | 3292.03 | 3326.36 | 1.29333 | 0.670114 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 498.82 | 40 | 32 | 42.4 | 37.2 | 1572.02 | 1588.41 | 0.69947 | 0.433477 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5764.08 | 40 | 32 | 42.4 | 37.2 | 1302.79 | 1316.37 | 0.496137 | 0.359237 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 1041.42 | 1052.28 | 1.28749 | 0.499358 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1666.45 | 30 | 25 | 33.7 | 28.5 | 1041.42 | 1052.28 | 1.28749 | 0.499358 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 884.46 | 30 | 25 | 33.7 | 28.5 | 887.745 | 897.002 | 0.960577 | 0.425673 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 618.511 | 624.96 | 0.498052 | 0.296575 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3492.06 | 30 | 25 | 33.7 | 28.5 | 618.511 | 624.96 | 0.498052 | 0.296575 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 401.009 | 20 | 20 | 26.9 | 22.3 | 349.276 | 352.918 | 0.546186 | 0.265071 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 401.009 | 20 | 20 | 26.9 | 22.3 | 349.276 | 352.918 | 0.546186 | 0.265071 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 618.511 | 624.96 | 0.498052 | 0.296575 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3492.06 | 30 | 25 | 33.7 | 28.5 | 618.511 | 624.96 | 0.498052 | 0.296575 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 688.671 | 30 | 25 | 33.7 | 28.5 | 887.745 | 897.002 | 0.960577 | 0.425673 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 1041.42 | 1052.28 | 1.28749 | 0.499358 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1842.23 | 30 | 25 | 33.7 | 28.5 | 1041.42 | 1052.28 | 1.28749 | 0.499358 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5784.08 | 40 | 32 | 42.4 | 37.2 | 1302.79 | 1316.37 | 0.496137 | 0.359237 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 541.379 | 40 | 32 | 42.4 | 37.2 | 1572.02 | 1588.41 | 0.69947 | 0.433477 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 40 | 32 | 42.4 | 37.2 | 1514.46 | 1530.25 | 0.653234 | 0.417604 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4670.66 | 40 | 32 | 42.4 | 37.2 | 1514.46 | 1530.25 | 0.653234 | 0.417604 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 455.012 | 40 | 32 | 42.4 | 37.2 | 1245.22 | 1258.21 | 0.456958 | 0.343364 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 502.605 | 30 | 25 | 33.7 | 28.5 | 706.753 | 714.122 | 0.634042 | 0.338887 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5763.37 | 30 | 25 | 33.7 | 28.5 | 644.78 | 651.503 | 0.536933 | 0.309171 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 241.45 | 20 | 20 | 26.9 | 22.3 | 599.019 | 605.265 | 1.45198 | 0.454604 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 60.5494 | 61.1808 | 0.0603875 | 0.0834777 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3389.01 | 20 | 15 | 21.3 | 17.3 | 60.5494 | 61.1808 | 0.0603875 | 0.0834777 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 60.5494 | 61.1808 | 0.0603875 | 0.0834777 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3709.01 | 20 | 15 | 21.3 | 17.3 | 60.5494 | 61.1808 | 0.0603875 | 0.0834777 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 561.445 | 20 | 20 | 26.9 | 22.3 | 599.019 | 605.265 | 1.45198 | 0.454604 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5523.38 | 30 | 25 | 33.7 | 28.5 | 644.78 | 651.503 | 0.536933 | 0.309171 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 822.6 | 30 | 25 | 33.7 | 28.5 | 706.753 | 714.122 | 0.634042 | 0.338887 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 455.012 | 40 | 32 | 42.4 | 37.2 | 1245.22 | 1258.21 | 0.456958 | 0.343364 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 40 | 32 | 42.4 | 37.2 | 1514.46 | 1530.25 | 0.653234 | 0.417604 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4713.22 | 40 | 32 | 42.4 | 37.2 | 1514.46 | 1530.25 | 0.653234 | 0.417604 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
3 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3292.03 | 3326.36 | 1.29333 | 0.670114 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2987.82 | 50 | 40 | 48.3 | 43.1 | 3292.03 | 3326.36 | 1.29333 | 0.670114 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 277.853 | 280.75 | 0.36292 | 0.210867 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 285.497 | 20 | 20 | 26.9 | 22.3 | 277.853 | 280.75 | 0.36292 | 0.210867 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 277.853 | 280.75 | 0.36292 | 0.210867 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 15.4967 | 20 | 20 | 26.9 | 22.3 | 277.853 | 280.75 | 0.36292 | 0.210867 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
5 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 303.104 | 306.265 | 0.423778 | 0.230031 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2755.36 | 20 | 20 | 26.9 | 22.3 | 303.104 | 306.265 | 0.423778 | 0.230031 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
5 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 20 | 26.9 | 22.3 | 303.104 | 306.265 | 0.423778 | 0.230031 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2793.63 | 20 | 20 | 26.9 | 22.3 | 303.104 | 306.265 | 0.423778 | 0.230031 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 230 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 925.218 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 512.151 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 391.757 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2174 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 761 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 434 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3220 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 412.739 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1239.4 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 137 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4660.56 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3005.2 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 888.292 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2330 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 155.773 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 137.089 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
2 x Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 5043.85 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3098.53 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 690.099 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3135 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 170.871 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 52.0885 | 20 | 15 | 21.3 | 17.3 | 151.84 | 153.424 | 0.527875 | 0.209338 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1034 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3220 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 699.739 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 726.067 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 137 | 30 | 25 | 33.7 | 28.5 | 688.156 | 695.332 | 0.60411 | 0.32997 | DN 25 | 33.7 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2c60be7f-547c-4aee-af43-fe217ef42dd3
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 337 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 617 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1267 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 982.218 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1112.15 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 891.757 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2574 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 461 | 70 | 65 | 76.1 | 70.3 | 9032.61 | 9126.8 | 0.715396 | 0.679967 | DN 65 | 76.1 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/d8baeff9-8956-40c0-bf92-8d098ca2f95c
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3164 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3835.36 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 904.211 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3478.04 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2356.79 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4194.71 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 133 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3446.52 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3168.28 | 3201.32 | 1.20426 | 0.644925 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3927.78 | 50 | 40 | 48.3 | 43.1 | 3168.28 | 3201.32 | 1.20426 | 0.644925 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2601.36 | 50 | 40 | 48.3 | 43.1 | 3168.28 | 3201.32 | 1.20426 | 0.644925 | DN 40 | 48.3 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4346.75 | 40 | 32 | 42.4 | 37.2 | 1816.08 | 1835.01 | 0.912066 | 0.500774 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 798.297 | 40 | 32 | 42.4 | 37.2 | 1816.08 | 1835.01 | 0.912066 | 0.500774 | DN 32 | 42.4 x 2.6 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2945.35 | 20 | 20 | 26.9 | 22.3 | 310.74 | 313.98 | 0.443031 | 0.235826 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4129.62 | 20 | 20 | 26.9 | 22.3 | 310.74 | 313.98 | 0.443031 | 0.235826 | DN 20 | 26.9 x 2.3 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1892.87 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 378.354 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1069.47 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4055 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 85 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 187.438 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 117.5 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2162.87 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 408.354 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 919.467 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3250 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 187.438 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 65 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 877.5 | 20 | 15 | 21.3 | 17.3 | 81.5139 | 82.3639 | 0.177556 | 0.112381 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2675.35 | 20 | 20 | 26.9 | 22.3 | 310.74 | 313.98 | 0.443031 | 0.235826 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3817.62 | 20 | 20 | 26.9 | 22.3 | 310.74 | 313.98 | 0.443031 | 0.235826 | DN 20 | 26.9 x 2.3 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/14bc917f-85b4-43a5-8021-b45e380a1b56
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4034.75 | 40 | 32 | 42.4 | 37.2 | 1816.08 | 1835.01 | 0.912066 | 0.500774 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 320.288 | 40 | 32 | 42.4 | 37.2 | 1816.08 | 1835.01 | 0.912066 | 0.500774 | DN 32 | 42.4 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/bafcb699-6e28-4064-877d-7f3198c9618f
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 50 | 40 | 48.3 | 43.1 | 3168.28 | 3201.32 | 1.20426 | 0.644925 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3785.41 | 50 | 40 | 48.3 | 43.1 | 3168.28 | 3201.32 | 1.20426 | 0.644925 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2213.36 | 50 | 40 | 48.3 | 43.1 | 3168.28 | 3201.32 | 1.20426 | 0.644925 | DN 40 | 48.3 x 2.6 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/7fcdd69a-1c4e-40f4-9cfd-de734c13b871
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3164 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3067.36 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 872.211 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3528.04 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2306.79 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 6000 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4412.71 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 133 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3714.52 | 60 | 50 | 60.3 | 54.5 | 4254.81 | 4299.18 | 0.642394 | 0.539267 | DN 50 | 60.3 x 2.9 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/59b151d6-5721-4e91-8f3a-88fbd33f4660
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2421.47 | 20 | 15 | 21.3 | 17.3 | 186.647 | 188.594 | 0.762113 | 0.257325 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1139.76 | 20 | 15 | 21.3 | 17.3 | 186.647 | 188.594 | 0.762113 | 0.257325 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4565.68 | 20 | 15 | 21.3 | 17.3 | 186.647 | 188.594 | 0.762113 | 0.257325 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 782.372 | 20 | 15 | 21.3 | 17.3 | 105.341 | 106.44 | 0.277366 | 0.145231 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 344.879 | 20 | 15 | 21.3 | 17.3 | 105.341 | 106.44 | 0.277366 | 0.145231 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3472.46 | 20 | 15 | 21.3 | 17.3 | 77.1152 | 77.9194 | 0.161314 | 0.106317 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2950 | 20 | 15 | 21.3 | 17.3 | 77.1152 | 77.9194 | 0.161314 | 0.106317 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 302.227 | 20 | 15 | 21.3 | 17.3 | 77.1152 | 77.9194 | 0.161314 | 0.106317 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 373.112 | 20 | 15 | 21.3 | 17.3 | 30.1519 | 30.4663 | 0.0300713 | 0.0415695 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 10 | 20 | 15 | 21.3 | 17.3 | 30.1519 | 30.4663 | 0.0300713 | 0.0415695 | DN 15 | 21.3 x 2 | H_Vorlauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 417.894 | 20 | 15 | 21.3 | 17.3 | 30.1519 | 30.4663 | 0.0300713 | 0.0415695 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3602.24 | 20 | 15 | 21.3 | 17.3 | 77.1152 | 77.9194 | 0.161314 | 0.106317 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3755 | 20 | 15 | 21.3 | 17.3 | 77.1152 | 77.9194 | 0.161314 | 0.106317 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 409.527 | 20 | 15 | 21.3 | 17.3 | 77.1152 | 77.9194 | 0.161314 | 0.106317 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 743.672 | 20 | 15 | 21.3 | 17.3 | 105.341 | 106.44 | 0.277366 | 0.145231 | DN 15 | 21.3 x 2 | H_Ruecklauf | 02d68179-ed5d-4232-b562-46366b7c6b07/2cae16ce-23f4-42d5-aa20-ac526bbebc82
