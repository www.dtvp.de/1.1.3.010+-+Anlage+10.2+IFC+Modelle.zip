Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2026-07-17T10:24:59+02:00
Author: Bra
Organization: IGW
Written by: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)
Made in: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)

# IfcSite: Projektstandort, Default
RefLatitude: 49, 0, 3571; RefLongitude: 12, 15, -2; RefElevation: 0 m

# IfcSite: Pyramidenstumpf (4)
Description: Pyramidenstumpf
Pset_Basis - Name: Pyramidenstumpf

# IfcBuilding: Gebäude, Speiseverteilzentrum SBW VZ II
Description: Speiseverteilzentrum SBW VZ II

# IfcBuildingStorey: Geschoss (4)
In: Speiseverteilzentrum SBW VZ II
Name | Description | Elevation (m)
Wartung_FFB | 2 | 7.1307
UK Thermische Hülle | 1 | 6.2307
EG_Verwaltung_FFB | 0 | 0.115653
Grundleitungsebene | -1 | -1.884

# IfcBuildingElementProxy: IfcProxy (89)
Description: IfcProxy
Name | In
3 x IfcProxy | Wartung_FFB
86 x IfcProxy | EG_Verwaltung_FFB

# IfcEnergyConversionDevice: Zentrale
In: EG_Verwaltung_FFB
Description: Zentrale

# IfcFlowController: Absperrklappe (26)
Description: Absperrklappe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Absperrklappe; Tech-Product item: Lokales Bauteil
Name | In | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Medium
3 x Absperrklappe | Wartung_FFB | 0 | 200 | H_Kaltwasser_RL
2 x Absperrklappe | Wartung_FFB | 0 |  | H_Kaltwasser_RL | Pset_MEP - Tech-DN1: 50
2 x Absperrklappe | Wartung_FFB | 0 |  | H_Kaltwasser_VL | Pset_MEP - Tech-DN1: 50
3 x Absperrklappe | Wartung_FFB | 0 | 200 | H_Kaltwasser_VL
Absperrklappe | EG_Verwaltung_FFB |  | 200 | H_Kaltwasser_VL
Absperrklappe | EG_Verwaltung_FFB |  | 200 | H_Kaltwasser_RL
Absperrklappe | EG_Verwaltung_FFB | 0 | 50 | H_Kaltwasser_VL
Absperrklappe | EG_Verwaltung_FFB | 0 | 175 | H_Kaltwasser_VL
Absperrklappe | EG_Verwaltung_FFB | 0 | 175 | H_Kaltwasser_RL
Absperrklappe | EG_Verwaltung_FFB | 0 | 40 | H_Kaltwasser_VL
Absperrklappe | EG_Verwaltung_FFB | 0 | 40 | H_Kaltwasser_RL
2 x Absperrklappe | EG_Verwaltung_FFB | 0 | 65 | H_Kaltwasser_RL
Absperrklappe | EG_Verwaltung_FFB | 0 | 50 | H_Kaltwasser_RL
Absperrklappe | EG_Verwaltung_FFB | 0 | 125 | H_Kaltwasser_RL
Absperrklappe | EG_Verwaltung_FFB | 0 | 100 | H_Kaltwasser_RL
Absperrklappe | EG_Verwaltung_FFB | 0 | 100 | H_Kaltwasser_VL
2 x Absperrklappe | EG_Verwaltung_FFB | 0 | 65 | H_Kaltwasser_VL
Absperrklappe | EG_Verwaltung_FFB | 0 | 125 | H_Kaltwasser_VL

# IfcFlowController: Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) (4)
In: Wartung_FFB
Description: Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h); Tech-Medium: H_Kaltwasser_RL; Tech-Product item: Lokales Bauteil
Name | Tech-DN | dp component (mbar) (hPa) | dp throttle (mbar) (hPa)
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 65 | 220 | 345.611
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 100 | 210 | 68.4628
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 125 | 205 | 282.971
Cocon QFC GG-Durchflussregler PN16 (1.5 - 190 kbm/h) | 50 | 265

# IfcFlowController: Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) (25)
In: EG_Verwaltung_FFB
Description: Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h); Tech-Medium: H_Kaltwasser_RL; Tech-Product item: Lokales Bauteil
Name | Tech-DN | dp component (mbar) (hPa) | dp throttle (mbar) (hPa) | dp (mbar) (Pa)
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 370.617 | 61561.7
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 25 | 353 | 153.535 | 50653.5
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 290 | 150.691 | 44069.1
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 290 | 157.058 | 44705.8
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 15 | 227 | 435.871 | 66287.1
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 15 | 227 | 436.481 | 66348.1
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 15 | 227 | 426.367 | 65336.7
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 15 | 227 | 424.393 | 65139.3
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 235.957 | 50795.7
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 25 | 311 | 157.77 | 46877
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 250.051 | 52205.1
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 243.702 | 51570.2
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 246.733 | 51873.3
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 239.887 | 51188.7
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 278.491 | 55049.1
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 393.757 | 63875.7
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 234.244 | 50624.4
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 258.499 | 53049.9
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 383.779 | 62877.9
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 272 | 228.486 | 50048.6
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 365.742 | 61074.2
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 371.113 | 61611.3
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 362.367 | 60736.7
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 379.386 | 62438.6
Cocon QTZ Ms-Durchflussregler PN16 (150-1050 l/h) | 20 | 245 | 373.967 | 61896.7

# IfcFlowController: Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) (5)
In: Wartung_FFB
Description: Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 32; Name: Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h); Tech-Medium: H_Kaltwasser_RL; Tech-Product item: Lokales Bauteil
Name | dp component (mbar) (hPa) | dp throttle (mbar) (hPa)
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 215 | 200.31
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 205 | 407.963
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 190 | 439.465
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 150 | 218.465
Cocon QTZ Ms-Durchflussregler PN16 (600-3600 l/h) | 150 | 188.232

# IfcFlowController: Hydrocontrol VFC GG-Strangregulierventil PN16
In: EG_Verwaltung_FFB
Description: Hydrocontrol VFC GG-Strangregulierventil PN16
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 175; dp component (mbar): 7.30895 hPa; Settings: 12; dp (mbar): 730.895 Pa; Name: Hydrocontrol VFC GG-Strangregulierventil PN16; Tech-Medium: H_Kaltwasser_RL; Tech-Product item: Lokales Bauteil

# IfcFlowController: Kugelhahn (2)
In: EG_Verwaltung_FFB
Description: Kugelhahn
Pset_MEP - Tech-DN: 200; Geom-Outer diameter (mm): 340 mm; Geom-Length (mm): 600 mm; Tech-Insulation thickness (mm): 19 mm; Tech-PN: 16; Tech-Connection type (Inner thread=2, flange=3): 2; Name: Kugelhahn

# IfcFlowController: Pumpe
In: EG_Verwaltung_FFB
Description: Pumpe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 175; dp (mbar): 90209.2 Pa; Nominal pressure (mbar): 902.092 hPa; Name: Pumpe; Tech-Medium: H_Kaltwasser_RL; Tech-Product item: Lokales Bauteil

# IfcFlowController: Schmutzfänger
In: EG_Verwaltung_FFB
Description: Schmutzfänger
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 175; Name: Schmutzfänger; Tech-Medium: H_Kaltwasser_RL; Tech-Product item: Lokales Bauteil

# IfcFlowController: Ventil Durchgang (34)
Description: Ventil Durchgang
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Ventil Durchgang; Tech-Medium: H_Kaltwasser_VL; Tech-Product item: Lokales Bauteil
Name | In | Tech-DN | Tech-Insulation thickness (mm) (mm)
Ventil Durchgang | Wartung_FFB | 65
2 x Ventil Durchgang | Wartung_FFB | 40
Ventil Durchgang | Wartung_FFB | 100
Ventil Durchgang | Wartung_FFB | 125
Ventil Durchgang | Wartung_FFB | 50
Ventil Durchgang | Wartung_FFB | 32
2 x Ventil Durchgang | Wartung_FFB | 25
19 x Ventil Durchgang | EG_Verwaltung_FFB | 20 | 0
2 x Ventil Durchgang | EG_Verwaltung_FFB | 25 | 0
4 x Ventil Durchgang | EG_Verwaltung_FFB | 15 | 0

# IfcFlowFitting: Bogen 90° (340)
Description: Bogen 90°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Bogen 90°; Tech-Catalog: Geberit; Tech-Product type: Bogen 90°; Tech-Manufacturer: Geberit
Name | In | Tech-DN | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
3 x Bogen 90° | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/be5f829b-33f2-48b4-af4c-4a96f913c570 | 41109 | -
3 x Bogen 90° | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/be5f829b-33f2-48b4-af4c-4a96f913c570 | 41109 | -
6 x Bogen 90° | Wartung_FFB | 40 | 20 | DN 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/d1109cc8-7086-4d8b-8b02-19057c96fd1e | 41107 | -
4 x Bogen 90° | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/088b0bfd-c2ab-4e47-bf34-564904fc50aa | 41108 | -
6 x Bogen 90° | Wartung_FFB | 40 | 20 | DN 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/d1109cc8-7086-4d8b-8b02-19057c96fd1e | 41107 | -
4 x Bogen 90° | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/088b0bfd-c2ab-4e47-bf34-564904fc50aa | 41108 | -
3 x Bogen 90° | Wartung_FFB | 100 | 20 | DN 100 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/bf881f36-8e80-4e33-ba52-c15c07d77c0c | 41111 | -
3 x Bogen 90° | Wartung_FFB | 100 | 20 | DN 100 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/bf881f36-8e80-4e33-ba52-c15c07d77c0c | 41111 | -
4 x Bogen 90° | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/088b0bfd-c2ab-4e47-bf34-564904fc50aa | 41108 | 332.118
4 x Bogen 90° | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/088b0bfd-c2ab-4e47-bf34-564904fc50aa | 41108 | 332.118
5 x Bogen 90° | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/be5f829b-33f2-48b4-af4c-4a96f913c570 | 41109 | 332.119
5 x Bogen 90° | Wartung_FFB | 32 | 20 | DN 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/89f9c75a-1eea-4093-ae7b-4af27d6e90b9 | 41106 | 332.116
6 x Bogen 90° | Wartung_FFB | 32 | 20 | DN 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/89f9c75a-1eea-4093-ae7b-4af27d6e90b9 | 41106 | 332.116
5 x Bogen 90° | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/be5f829b-33f2-48b4-af4c-4a96f913c570 | 41109 | 332.119
21 x Bogen 90° | Wartung_FFB | 25 | 20 | DN 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1986e024-ce0b-4c20-bd56-ff15644172e4 | 41105 | 332.115
21 x Bogen 90° | Wartung_FFB | 25 | 20 | DN 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1986e024-ce0b-4c20-bd56-ff15644172e4 | 41105 | 332.115
5 x Bogen 90° | EG_Verwaltung_FFB | 50 | 19 | DN 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/088b0bfd-c2ab-4e47-bf34-564904fc50aa | 41108 | 332.118
9 x Bogen 90° | EG_Verwaltung_FFB | 65 | 19 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/be5f829b-33f2-48b4-af4c-4a96f913c570 | 41109 | 332.119
5 x Bogen 90° | EG_Verwaltung_FFB | 50 | 19 | DN 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/088b0bfd-c2ab-4e47-bf34-564904fc50aa | 41108 | 332.118
4 x Bogen 90° | EG_Verwaltung_FFB | 32 | 19 | DN 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/89f9c75a-1eea-4093-ae7b-4af27d6e90b9 | 41106 | 332.116
27 x Bogen 90° | EG_Verwaltung_FFB | 25 | 19 | DN 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1986e024-ce0b-4c20-bd56-ff15644172e4 | 41105 | 332.115
55 x Bogen 90° | EG_Verwaltung_FFB | 20 | 19 | DN 20 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/f7baf9e7-742f-4193-be27-91f80e9d480e | 41104 | 332.114
55 x Bogen 90° | EG_Verwaltung_FFB | 20 | 19 | DN 20 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/f7baf9e7-742f-4193-be27-91f80e9d480e | 41104 | 332.114
27 x Bogen 90° | EG_Verwaltung_FFB | 25 | 19 | DN 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1986e024-ce0b-4c20-bd56-ff15644172e4 | 41105 | 332.115
4 x Bogen 90° | EG_Verwaltung_FFB | 32 | 19 | DN 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/89f9c75a-1eea-4093-ae7b-4af27d6e90b9 | 41106 | 332.116
8 x Bogen 90° | EG_Verwaltung_FFB | 65 | 19 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/be5f829b-33f2-48b4-af4c-4a96f913c570 | 41109 | 332.119
5 x Bogen 90° | EG_Verwaltung_FFB | 40 | 19 | DN 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/d1109cc8-7086-4d8b-8b02-19057c96fd1e | 41107 | 332.117
5 x Bogen 90° | EG_Verwaltung_FFB | 40 | 19 | DN 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/d1109cc8-7086-4d8b-8b02-19057c96fd1e | 41107 | 332.117
12 x Bogen 90° | EG_Verwaltung_FFB | 15 | 19 | DN 15 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/45d1fe3d-d4b4-42de-a247-6661252e3c6f | 41103 | 332.113
12 x Bogen 90° | EG_Verwaltung_FFB | 15 | 19 | DN 15 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/45d1fe3d-d4b4-42de-a247-6661252e3c6f | 41103 | 332.113
2 x Bogen 90° | EG_Verwaltung_FFB | 100 | 19 | DN 100 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/bf881f36-8e80-4e33-ba52-c15c07d77c0c | 41111 | 332.122
2 x Bogen 90° | EG_Verwaltung_FFB | 100 | 19 | DN 100 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/bf881f36-8e80-4e33-ba52-c15c07d77c0c | 41111 | 332.122

# IfcFlowFitting: Muffe (120)
Description: Muffe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Muffe; Tech-Catalog: Geberit; Tech-Product type: Muffe; Tech-Manufacturer: Geberit
Name | In | Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number | Tech-DN
2 x Muffe | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1878697e-2e3a-47ac-ab5f-9c87722a5983 | 44009 | - | Pset_MEP - Tech-DN1: 65
2 x Muffe | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1878697e-2e3a-47ac-ab5f-9c87722a5983 | 44009 | - | Pset_MEP - Tech-DN1: 65
5 x Muffe | Wartung_FFB | 40 | 20 | DN 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/86cdbd11-f981-428d-a044-7869b8c07cee | 44007 | - | Pset_MEP - Tech-DN1: 40
Muffe | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/820015bb-6c23-4802-8dc2-dbef75fbf439 | 44008 | - | Pset_MEP - Tech-DN1: 50
5 x Muffe | Wartung_FFB | 40 | 20 | DN 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/86cdbd11-f981-428d-a044-7869b8c07cee | 44007 | - | Pset_MEP - Tech-DN1: 40
Muffe | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/820015bb-6c23-4802-8dc2-dbef75fbf439 | 44008 | - | Pset_MEP - Tech-DN1: 50
4 x Muffe | Wartung_FFB | 100 | 20 | DN 100 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/203f7bb8-7b13-4e9b-a088-01bf9026aae3 | 44011 | - | Pset_MEP - Tech-DN1: 100
3 x Muffe | Wartung_FFB | 100 | 20 | DN 100 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/203f7bb8-7b13-4e9b-a088-01bf9026aae3 | 44011 | - | Pset_MEP - Tech-DN1: 100
2 x Muffe | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/820015bb-6c23-4802-8dc2-dbef75fbf439 | 44008 | 333.118 | Pset_MEP - Tech-DN1: 50
2 x Muffe | Wartung_FFB | 50 | 20 | DN 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/820015bb-6c23-4802-8dc2-dbef75fbf439 | 44008 | 333.118 | Pset_MEP - Tech-DN1: 50
6 x Muffe | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1878697e-2e3a-47ac-ab5f-9c87722a5983 | 44009 | 333.119 | Pset_MEP - Tech-DN1: 65
2 x Muffe | Wartung_FFB | 32 | 20 | DN 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/c814a3e8-ef09-4bfe-9c44-e05b0a1a7043 | 44006 | 333.116 | Pset_MEP - Tech-DN1: 32
2 x Muffe | Wartung_FFB | 32 | 20 | DN 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/c814a3e8-ef09-4bfe-9c44-e05b0a1a7043 | 44006 | 333.116 | Pset_MEP - Tech-DN1: 32
6 x Muffe | Wartung_FFB | 65 | 20 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1878697e-2e3a-47ac-ab5f-9c87722a5983 | 44009 | 333.119 | Pset_MEP - Tech-DN1: 65
22 x Muffe | Wartung_FFB | 25 | 20 | DN 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/735010f7-b58f-443e-b1e0-14cd80812180 | 44005 | 333.115 | 125
22 x Muffe | Wartung_FFB | 25 | 20 | DN 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/735010f7-b58f-443e-b1e0-14cd80812180 | 44005 | 333.115 | 125
3 x Muffe | EG_Verwaltung_FFB | 65 | 19 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1878697e-2e3a-47ac-ab5f-9c87722a5983 | 44009 | 333.119 | Pset_MEP - Tech-DN1: 65
Muffe | EG_Verwaltung_FFB | 50 | 19 | DN 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/820015bb-6c23-4802-8dc2-dbef75fbf439 | 44008 | 333.118 | Pset_MEP - Tech-DN1: 50
Muffe | EG_Verwaltung_FFB | 32 | 19 | DN 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/c814a3e8-ef09-4bfe-9c44-e05b0a1a7043 | 44006 | 333.116 | Pset_MEP - Tech-DN1: 32
Muffe | EG_Verwaltung_FFB | 32 | 19 | DN 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/c814a3e8-ef09-4bfe-9c44-e05b0a1a7043 | 44006 | 333.116 | Pset_MEP - Tech-DN1: 32
Muffe | EG_Verwaltung_FFB | 50 | 19 | DN 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/820015bb-6c23-4802-8dc2-dbef75fbf439 | 44008 | 333.118 | Pset_MEP - Tech-DN1: 50
3 x Muffe | EG_Verwaltung_FFB | 65 | 19 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1878697e-2e3a-47ac-ab5f-9c87722a5983 | 44009 | 333.119 | Pset_MEP - Tech-DN1: 65
10 x Muffe | EG_Verwaltung_FFB | 25 | 19 | DN 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/735010f7-b58f-443e-b1e0-14cd80812180 | 44005 | 333.115 | 125
9 x Muffe | EG_Verwaltung_FFB | 25 | 19 | DN 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/735010f7-b58f-443e-b1e0-14cd80812180 | 44005 | 333.115 | 125
2 x Muffe | EG_Verwaltung_FFB | 40 | 19 | DN 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/86cdbd11-f981-428d-a044-7869b8c07cee | 44007 | 333.117 | Pset_MEP - Tech-DN1: 40
2 x Muffe | EG_Verwaltung_FFB | 40 | 19 | DN 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/86cdbd11-f981-428d-a044-7869b8c07cee | 44007 | 333.117 | Pset_MEP - Tech-DN1: 40

# IfcFlowFitting: Reduktion mit Einschubende (50)
Description: Reduktion mit Einschubende
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Reduktion mit Einschubende; Tech-Catalog: Geberit; Tech-Product type: Reduktion mit Einschubende; Tech-Manufacturer: Geberit
Name | In | Tech-DN1 | Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Reduktion mit Einschubende | Wartung_FFB | 50 | 40 | 20 | DN 50 - 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/56de436b-40e9-45fc-87fd-2acc5fdf1727 | 42424 | -
Reduktion mit Einschubende | Wartung_FFB | 50 | 40 | 20 | DN 50 - 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/56de436b-40e9-45fc-87fd-2acc5fdf1727 | 42424 | -
Reduktion mit Einschubende | Wartung_FFB | 65 | 50 | 20 | DN 65 - 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/76266f05-395d-40bf-bc23-f62ecd626122 | 42428 | 333.219
Reduktion mit Einschubende | Wartung_FFB | 65 | 50 | 20 | DN 65 - 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/76266f05-395d-40bf-bc23-f62ecd626122 | 42428 | 333.219
2 x Reduktion mit Einschubende | Wartung_FFB | 32 | 25 | 20 | DN 32 - 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/4f991af1-18c2-42da-9ae0-8fb2af538b56 | 42413 | 333.216
2 x Reduktion mit Einschubende | Wartung_FFB | 32 | 25 | 20 | DN 32 - 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/4f991af1-18c2-42da-9ae0-8fb2af538b56 | 42413 | 333.216
4 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 40 | 32 | 19 | DN 40 - 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a8ebf41c-953f-48d1-8b7c-572e9c1af11b | 42418 | 333.217
4 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 40 | 32 | 19 | DN 40 - 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a8ebf41c-953f-48d1-8b7c-572e9c1af11b | 42418 | 333.217
5 x Reduktion mit Einschubende | EG_Verwaltung_FFB |  | 20 | 19 | DN 25 - 20 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/208e9d58-e7a2-4aca-8704-99345e1e7ccc | 42409 | 333.215 | Pset_MEP - Tech-DN: 125
5 x Reduktion mit Einschubende | EG_Verwaltung_FFB |  | 20 | 19 | DN 25 - 20 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/208e9d58-e7a2-4aca-8704-99345e1e7ccc | 42409 | 333.215 | Pset_MEP - Tech-DN: 125
4 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 32 | 25 | 19 | DN 32 - 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/4f991af1-18c2-42da-9ae0-8fb2af538b56 | 42413 | 333.216
4 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 32 | 25 | 19 | DN 32 - 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/4f991af1-18c2-42da-9ae0-8fb2af538b56 | 42413 | 333.216
2 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 50 | 40 | 19 | DN 50 - 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/56de436b-40e9-45fc-87fd-2acc5fdf1727 | 42424 | 333.218
2 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 50 | 40 | 19 | DN 50 - 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/56de436b-40e9-45fc-87fd-2acc5fdf1727 | 42424 | 333.218
3 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 65 | 50 | 19 | DN 65 - 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/76266f05-395d-40bf-bc23-f62ecd626122 | 42428 | 333.219
3 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 65 | 50 | 19 | DN 65 - 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/76266f05-395d-40bf-bc23-f62ecd626122 | 42428 | 333.219
Reduktion mit Einschubende | EG_Verwaltung_FFB | 20 | 15 | 19 | DN 20 - 15 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/7580e9d0-a962-45db-ab93-38d922ba804e | 42406 | 333.214
Reduktion mit Einschubende | EG_Verwaltung_FFB | 20 | 15 | 19 | DN 20 - 15 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/7580e9d0-a962-45db-ab93-38d922ba804e | 42406 | 333.214
2 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 32 | 20 | 19 | DN 32 - 20 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ef82f9ca-9b2b-4993-aedd-4a272bc502cc | 42412 | 333.216
2 x Reduktion mit Einschubende | EG_Verwaltung_FFB | 32 | 20 | 19 | DN 32 - 20 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ef82f9ca-9b2b-4993-aedd-4a272bc502cc | 42412 | 333.216

# IfcFlowFitting: Reduzierung Bauart 1 (5)
Description: Reduzierung Bauart 1
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: Reduzierung Bauart 1; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Reduzierung Bauart 1; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN1 | Tech-DN2 | Info | Tech-Medium | Tech-Product item
Reduzierung Bauart 1 | Wartung_FFB | 200 | 150 | DN 200 - 150 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/edf78166-94f5-4dc1-adb3-0ec264e0dad6
Reduzierung Bauart 1 | Wartung_FFB | 200 | 150 | DN 200 - 150 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/edf78166-94f5-4dc1-adb3-0ec264e0dad6
Reduzierung Bauart 1 | EG_Verwaltung_FFB | 175 | 125 | DN 175 - 125 (ausserhalb der Norm) | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/032bd4a8-c405-4e54-97f9-2ddb1632c046
Reduzierung Bauart 1 | EG_Verwaltung_FFB | 125 | 65 | DN 125 - 65 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/7e0285ec-34c7-4afe-a20c-a53876344af9
Reduzierung Bauart 1 | EG_Verwaltung_FFB | 175 | 150 | DN 175 - 150 (ausserhalb der Norm) | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/5ac31bfd-a47e-4258-8502-8ad3978a325c

# IfcFlowFitting: Reduzierung Typ A, Konzentrisch (2)
In: EG_Verwaltung_FFB
Description: Reduzierung Typ A, Konzentrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN1: 150; Tech-DN2: 65; Tech-Insulation thickness (mm): 19 mm; Name: Reduzierung Typ A, Konzentrisch; Info: DN 150 - 65; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Reduzierung Typ A, Konzentrisch; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/06273de0-9849-4620-b834-7c8a38c33ea8; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-Medium
Reduzierung Typ A, Konzentrisch | H_Kaltwasser_VL
Reduzierung Typ A, Konzentrisch | H_Kaltwasser_RL

# IfcFlowFitting: Rohrbogen (20)
Description: Rohrbogen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohrbogen; Tech-Product item: Lokales Bauteil
Name | In | Tech-DN | Tech-Insulation thickness (mm) (mm) | Tech-Medium
7 x Rohrbogen | Wartung_FFB | 125 | 20 | H_Kaltwasser_RL
7 x Rohrbogen | Wartung_FFB | 125 | 20 | H_Kaltwasser_VL
Rohrbogen | EG_Verwaltung_FFB | 200 | 20 | H_Kaltwasser_VL
Rohrbogen | EG_Verwaltung_FFB | 200 | 20 | H_Kaltwasser_RL
2 x Rohrbogen | EG_Verwaltung_FFB | 200 | 19 | H_Kaltwasser_RL | Pset_MEP - Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
2 x Rohrbogen | EG_Verwaltung_FFB | 200 | 19 | H_Kaltwasser_VL | Pset_MEP - Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -

# IfcFlowFitting: Rohrbogen Bauart 2 D 90° (45)
Description: Rohrbogen Bauart 2 D 90°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: Rohrbogen Bauart 2 D 90°; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Rohrbogen Bauart 2 D 90°; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Info | Tech-Medium | Tech-Product item | Tech-DN1
8 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | DN 200 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/e9a86794-7e36-4276-8428-c796a907dca0 | Pset_MEP - Tech-DN: 200
10 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | DN 150 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f | 50
10 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | DN 150 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f | 50
8 x Rohrbogen Bauart 2 D 90° | Wartung_FFB | DN 200 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/e9a86794-7e36-4276-8428-c796a907dca0 | Pset_MEP - Tech-DN: 200
2 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | DN 150 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f | 50
Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | DN 175 (ausserhalb der Norm) | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/ae02bef2-a4b4-4af5-a0e3-75e2737e2156 | Pset_MEP - Tech-DN: 175
2 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | DN 150 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/0cd5e496-e045-4d32-937c-9982b398ec2f | 50
2 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | DN 125 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/d27f4347-e7f4-4b5a-8106-d6ca333a5085 | Pset_MEP - Tech-DN: 125
2 x Rohrbogen Bauart 2 D 90° | EG_Verwaltung_FFB | DN 125 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/d27f4347-e7f4-4b5a-8106-d6ca333a5085 | Pset_MEP - Tech-DN: 125

# IfcFlowFitting: T-Stück (4)
Description: T-Stück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: T-Stück; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN1 = Tech-DN2 = Tech-DN3 | Info | Tech-Medium | Tech-Product item
T-Stück | Wartung_FFB | 200 | DN 200 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/7fc242a3-5df7-44d7-a33f-6eeacb3131bf
T-Stück | Wartung_FFB | 200 | DN 200 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/7fc242a3-5df7-44d7-a33f-6eeacb3131bf
T-Stück | EG_Verwaltung_FFB | 175 | DN 175 (ausserhalb der Norm) | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/9307a8ce-0fef-4d4d-aba3-983a1cf9a617
T-Stück | EG_Verwaltung_FFB | 175 | DN 175 (ausserhalb der Norm) | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/9307a8ce-0fef-4d4d-aba3-983a1cf9a617

# IfcFlowFitting: T-Stück egal (14)
Description: T-Stück egal
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: T-Stück egal; Tech-Catalog: Geberit; Tech-Product type: T-Stück egal; Tech-Manufacturer: Geberit
Name | In | Tech-DN1 = Tech-DN2 = Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
T-Stück egal | Wartung_FFB | 32 | 20 | DN 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1f120eea-84e1-4616-993f-72e02af9d173 | 43006 | 334.116
T-Stück egal | Wartung_FFB | 32 | 20 | DN 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1f120eea-84e1-4616-993f-72e02af9d173 | 43006 | 334.116
4 x T-Stück egal | EG_Verwaltung_FFB | 65 | 19 | DN 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/db4a76af-f697-4f2a-9479-e8e40d4e2ff8 | 43009 | 334.119
4 x T-Stück egal | EG_Verwaltung_FFB | 65 | 19 | DN 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/db4a76af-f697-4f2a-9479-e8e40d4e2ff8 | 43009 | 334.119
T-Stück egal | EG_Verwaltung_FFB | 40 | 19 | DN 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/5406464f-fb33-4a6d-9336-6cffc61d1aa6 | 43007 | 334.117
T-Stück egal | EG_Verwaltung_FFB | 40 | 19 | DN 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/5406464f-fb33-4a6d-9336-6cffc61d1aa6 | 43007 | 334.117
T-Stück egal | EG_Verwaltung_FFB | 32 | 19 | DN 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1f120eea-84e1-4616-993f-72e02af9d173 | 43006 | 334.116
T-Stück egal | EG_Verwaltung_FFB | 32 | 19 | DN 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1f120eea-84e1-4616-993f-72e02af9d173 | 43006 | 334.116

# IfcFlowFitting: T-Stück reduziert (44)
Description: T-Stück reduziert
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: T-Stück reduziert; Tech-Catalog: Geberit; Tech-Product type: T-Stück reduziert; Tech-Manufacturer: Geberit
Name | In | Tech-DN1 | Tech-DN2 | Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
T-Stück reduziert | Wartung_FFB | 50 | 50 | 40 | 20 | DN 50 - 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/8c5daa1b-cb7e-41de-8af6-2eff7d571c9b | 41226 | -
T-Stück reduziert | Wartung_FFB | 50 | 50 | 40 | 20 | DN 50 - 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/8c5daa1b-cb7e-41de-8af6-2eff7d571c9b | 41226 | -
T-Stück reduziert | Wartung_FFB | 65 | 65 | 32 | 20 | DN 65 - 32 - 65 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/b527cde2-f3d3-4db3-a90c-408fe2105dbc | 41231 | 334.219
T-Stück reduziert | Wartung_FFB | 65 | 65 | 32 | 20 | DN 65 - 32 - 65 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/b527cde2-f3d3-4db3-a90c-408fe2105dbc | 41231 | 334.219
T-Stück reduziert | EG_Verwaltung_FFB | 50 | 50 | 32 | 19 | DN 50 - 32 - 50 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/c16abea4-9b68-4f10-a9e2-51ef5063c914 | 41225 | 334.218
2 x T-Stück reduziert | EG_Verwaltung_FFB | 32 | 32 | 25 | 19 | DN 32 - 25 - 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/1a637416-63ad-4bda-9027-dd8dfb7020b7 | 41215 | 334.216
8 x T-Stück reduziert | EG_Verwaltung_FFB |  | 25 | 20 | 19 | DN 25 - 20 - 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/3ca2ee6b-ec80-494d-9341-4eb50d648730 | 41211 | 334.214 | Pset_MEP - Tech-DN: 125
8 x T-Stück reduziert | EG_Verwaltung_FFB |  | 25 | 20 | 19 | DN 25 - 20 - 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/3ca2ee6b-ec80-494d-9341-4eb50d648730 | 41211 | 334.214 | Pset_MEP - Tech-DN: 125
2 x T-Stück reduziert | EG_Verwaltung_FFB | 32 | 32 | 25 | 19 | DN 32 - 25 - 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/1a637416-63ad-4bda-9027-dd8dfb7020b7 | 41215 | 334.216
T-Stück reduziert | EG_Verwaltung_FFB | 50 | 50 | 32 | 19 | DN 50 - 32 - 50 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/c16abea4-9b68-4f10-a9e2-51ef5063c914 | 41225 | 334.218
2 x T-Stück reduziert | EG_Verwaltung_FFB | 40 | 40 | 32 | 19 | DN 40 - 32 - 40 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9e6bad34-ab63-4e1e-b7ad-d66879e9e130 | 41220 | 334.217
2 x T-Stück reduziert | EG_Verwaltung_FFB | 40 | 40 | 32 | 19 | DN 40 - 32 - 40 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9e6bad34-ab63-4e1e-b7ad-d66879e9e130 | 41220 | 334.217
2 x T-Stück reduziert | EG_Verwaltung_FFB |  | 25 | 15 | 19 | DN 25 - 15 - 25 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/8ae3f3da-67ba-4bb9-beb3-38329a55aff4 | 41210 | 334.214 | Pset_MEP - Tech-DN: 125
2 x T-Stück reduziert | EG_Verwaltung_FFB |  | 25 | 15 | 19 | DN 25 - 15 - 25 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/8ae3f3da-67ba-4bb9-beb3-38329a55aff4 | 41210 | 334.214 | Pset_MEP - Tech-DN: 125
T-Stück reduziert | EG_Verwaltung_FFB | 20 | 20 | 15 | 19 | DN 20 - 15 - 20 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/3afc177e-fc2c-490b-80cc-d2ebfb4d8e9b | 41207 | 334.213
T-Stück reduziert | EG_Verwaltung_FFB | 20 | 20 | 15 | 19 | DN 20 - 15 - 20 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/3afc177e-fc2c-490b-80cc-d2ebfb4d8e9b | 41207 | 334.213
4 x T-Stück reduziert | EG_Verwaltung_FFB | 32 | 32 | 20 | 19 | DN 32 - 20 - 32 | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/90812057-718c-49b6-976e-7e4d3154efa1 | 41214 | 334.216
4 x T-Stück reduziert | EG_Verwaltung_FFB | 32 | 32 | 20 | 19 | DN 32 - 20 - 32 | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/90812057-718c-49b6-976e-7e4d3154efa1 | 41214 | 334.216

# IfcFlowFitting: T-Stück, reduziert (8)
Description: T-Stück, reduziert
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: T-Stück, reduziert; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück, reduziert; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN1 = Tech-DN2 | Tech-DN3 | Info | Tech-Medium | Tech-Product item
T-Stück, reduziert | Wartung_FFB | 200 | 150 | DN 200 - 150 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/454164e4-efb2-4aa4-82c5-35e01b98b19e
T-Stück, reduziert | Wartung_FFB | 200 | 150 | DN 200 - 150 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/454164e4-efb2-4aa4-82c5-35e01b98b19e
T-Stück, reduziert | EG_Verwaltung_FFB | 150 | 125 | DN 150 - 125 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/24bed32a-2681-4765-b3f8-607d620dd634
T-Stück, reduziert | EG_Verwaltung_FFB | 150 | 65 | DN 150 - 65 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/701c75db-b18b-49ca-bae1-12289bca03a8
T-Stück, reduziert | EG_Verwaltung_FFB | 150 | 100 | DN 150 - 100 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/58a4f1e8-8194-49ca-8ec5-19992141260a
T-Stück, reduziert | EG_Verwaltung_FFB | 150 | 100 | DN 150 - 100 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/58a4f1e8-8194-49ca-8ec5-19992141260a
T-Stück, reduziert | EG_Verwaltung_FFB | 150 | 65 | DN 150 - 65 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/701c75db-b18b-49ca-bae1-12289bca03a8
T-Stück, reduziert | EG_Verwaltung_FFB | 150 | 125 | DN 150 - 125 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/24bed32a-2681-4765-b3f8-607d620dd634

# IfcFlowFitting: Übergangsstück (11)
In: EG_Verwaltung_FFB
Description: Übergangsstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: Übergangsstück; Tech-Product item: Lokales Bauteil
Name | Tech-DN1 | Tech-Medium
3 x Übergangsstück | 65 | H_Kaltwasser_VL
2 x Übergangsstück | 65 | H_Kaltwasser_RL
Übergangsstück | 175 | H_Kaltwasser_RL | Pset_MEP - Tech-DN2: 65
Übergangsstück | 65 | H_Kaltwasser_VL | Pset_MEP - Tech-DN2: 25
Übergangsstück | 65 | H_Kaltwasser_RL | Pset_MEP - Tech-DN2: 25
Übergangsstück | 175 | H_Kaltwasser_RL | Pset_MEP - Tech-DN2: 150
Übergangsstück | 100 | H_Kaltwasser_RL
Übergangsstück | 100 | H_Kaltwasser_VL

# IfcFlowMovingDevice: SLK Deckenkassette (22)
In: EG_Verwaltung_FFB
Description: SLK Deckenkassette
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: SLK Deckenkassette
Name | Info
SLK Deckenkassette | 2,3 kW
SLK Deckenkassette | 2,0 kW
SLK Deckenkassette | 2,2 kW
SLK Deckenkassette | 1,8 kW
6 x SLK Deckenkassette | 2,1 kW
5 x SLK Deckenkassette | 1,4 kW
6 x SLK Deckenkassette | 1,5 kW
SLK Deckenkassette | 3,4 kW

# IfcFlowMovingDevice: SLK Wandgerät (5)
Description: SLK Wandgerät
Pset_MEP - Name: SLK Wandgerät
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Name | In | Info
2 x SLK Wandgerät | Wartung_FFB | 3,2 kW
SLK Wandgerät | EG_Verwaltung_FFB | 4,2 kW
SLK Wandgerät | EG_Verwaltung_FFB | 1,7 kW
SLK Wandgerät | EG_Verwaltung_FFB | 1,6 kW

# IfcFlowSegment: Gewindestahlrohr DIN 2448 (20)
Description: Gewindestahlrohr DIN 2448
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 20 mm; Name: Gewindestahlrohr DIN 2448; Tech-Product item: Lokales Bauteil
Name | In | Geom-Length (mm) (m) | Tech-DN = Tech-Outside diameter (mm) (mm) = Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Tech-Medium
Gewindestahlrohr DIN 2448 | Wartung_FFB | 1110.3 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 1926.03 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 9605.04 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 1620.6 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 5580.15 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 12124.5 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 8102.65 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 130.852 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 3010.3 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_RL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 1110.3 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 2126.03 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 9905.04 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 1620.6 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 5280.15 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 12124.5 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 8402.65 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 130.852 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | Wartung_FFB | 3010.3 | 125 | 28345.2 | 28368.4 | 0.268375 | 0.578458 | 139,7 x 4 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | EG_Verwaltung_FFB | 3615.9 | 200 | 166736 | 166873 | 0.780142 | 1.38406 | 219 x 6,3 | H_Kaltwasser_VL
Gewindestahlrohr DIN 2448 | EG_Verwaltung_FFB | 5515.9 | 200 | 166736 | 166873 | 0.780142 | 1.38406 | 219 x 6,3 | H_Kaltwasser_RL

# IfcFlowSegment: Rohr (6)
In: EG_Verwaltung_FFB
Description: Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: Rohr; Tech-Product item: Lokales Bauteil
Name | Geom-Length (mm) (m) | Tech-DN = Tech-Outside diameter (mm) (mm) = Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Tech-Medium
Rohr | 69.9965 | 50 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | H_Kaltwasser_VL
Rohr | 36 | 25 | 819.308 | 819.98 | 1.20208 | 0.442518 | H_Kaltwasser_RL
Rohr | 36 | 25 | 819.308 | 819.98 | 1.20208 | 0.442518 | H_Kaltwasser_VL
Rohr | 32 | 25 | 718.691 | 719.281 | 0.957812 | 0.388174 | H_Kaltwasser_VL
Rohr | 32 | 25 | 718.691 | 719.281 | 0.957812 | 0.388174 | H_Kaltwasser_RL
Rohr | 70.0002 | 50 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | H_Kaltwasser_RL

# IfcFlowSegment: Rohr DIN EN 10220 (106)
Description: Rohr DIN EN 10220
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 19 mm; Name: Rohr DIN EN 10220; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Rohr DIN EN 10220; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Geom-Length (mm) (m) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | Wartung_FFB | 2047 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 362.524 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 494 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
12 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3182.67 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 64.6604 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 347.567 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 4723.91 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1044 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1488.54 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 248 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
3 x Rohr DIN EN 10220 | Wartung_FFB | 46 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 636.153 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 3781.24 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 612.692 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 2677.47 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 2650.03 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 71.6174 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
3 x Rohr DIN EN 10220 | Wartung_FFB | 46 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 1669.28 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 3781.24 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 612.692 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 2677.47 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 2650.03 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 30 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
