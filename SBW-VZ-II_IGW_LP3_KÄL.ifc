Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcFlowSegment: Rohr DIN EN 10220 (106)
Name | In | Geom-Length (mm) (m) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Info | Info 1 | Tech-Medium | Tech-Product item
Rohr DIN EN 10220 | Wartung_FFB | 3216.36 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 30 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 3516.36 |  | 168.3 | 159.3 | 83368.2 | 83436.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50
Rohr DIN EN 10220 | Wartung_FFB | 82.1028 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 4947.48 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1044 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
12 x Rohr DIN EN 10220 | Wartung_FFB | 6000 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1588.54 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 2047 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 362.524 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 494 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3443.05 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 146.174 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 769 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 179.956 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1696.6 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 2060 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 769 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 61.8565 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 1806.7 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 2400 | 200 | 219.1 | 206.5 | 166736 | 166873 | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3867 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | Wartung_FFB | 3867 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3867 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3867 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 292.529 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 852.29 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2072.29 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 402.914 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 881.866 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1941.29 | 200 | 219.1 | 206.5 |  |  | DN 200 | 219.1 x 6.3 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/c96b6f7a-e7b2-4cbf-ab65-8b82043433e4
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 314.002 |  | 168.3 | 159.3 | 39384.3 | 39416.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.193307 hPa/m; Calc-Velocitiy (m/s): 0.549358 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 314.002 |  | 168.3 | 159.3 | 45478.8 | 45516.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.251576 hPa/m; Calc-Velocitiy (m/s): 0.634368 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 314.002 |  | 168.3 | 159.3 | 45478.8 | 45516.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.251576 hPa/m; Calc-Velocitiy (m/s): 0.634368 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 314.002 |  | 168.3 | 159.3 | 39384.3 | 39416.6 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.193307 hPa/m; Calc-Velocitiy (m/s): 0.549358 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 276 |  | 168.3 | 159.3 | 59867 | 59916.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.417333 hPa/m; Calc-Velocitiy (m/s): 0.835064 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3337.91 |  | 168.3 | 159.3 | 59867 | 59916.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.417333 hPa/m; Calc-Velocitiy (m/s): 0.835064 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 203.492 |  | 168.3 | 159.3 | 59867 | 59916.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.417333 hPa/m; Calc-Velocitiy (m/s): 0.835064 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 126.106 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 3985.31 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 1268 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 126.106 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 569.996 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 545 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 435 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 493.314 | 175 | 193.7 | 182.5 | 69576.5 | 69633.6 | DN 175 (ausserhalb der Norm) | 193.7 x 5.6 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/584ef9d6-f150-42a1-838c-48ab7b02ddde | Pset_MEP - Calc-R (mbar/m): 0.282408 hPa/m; Calc-Velocitiy (m/s): 0.739436 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 103.491 |  | 168.3 | 159.3 | 59867 | 59916.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.417333 hPa/m; Calc-Velocitiy (m/s): 0.835064 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 2637.92 |  | 168.3 | 159.3 | 59867 | 59916.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.417333 hPa/m; Calc-Velocitiy (m/s): 0.835064 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 64.75 |  | 168.3 | 159.3 | 59867 | 59916.1 | DN 150 | 168.3 x 4.5 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/95dc0e5a-fdf6-4754-aa96-c2074319fb74 | Pset_MEP - Tech-DN1: 50; Calc-R (mbar/m): 0.417333 hPa/m; Calc-Velocitiy (m/s): 0.835064 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4308 | 125 | 139.7 | 131.7 | 28345.2 | 28368.4 | DN 125 | 139.7 x 4 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52 | Pset_MEP - Calc-R (mbar/m): 0.268375 hPa/m; Calc-Velocitiy (m/s): 0.578458 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 648 | 125 | 139.7 | 131.7 | 28345.2 | 28368.4 | DN 125 | 139.7 x 4 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52 | Pset_MEP - Calc-R (mbar/m): 0.268375 hPa/m; Calc-Velocitiy (m/s): 0.578458 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 388 | 125 | 139.7 | 131.7 | 28345.2 | 28368.4 | DN 125 | 139.7 x 4 | H_Kaltwasser_RL | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52 | Pset_MEP - Calc-R (mbar/m): 0.268375 hPa/m; Calc-Velocitiy (m/s): 0.578458 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 4308 | 125 | 139.7 | 131.7 | 28345.2 | 28368.4 | DN 125 | 139.7 x 4 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52 | Pset_MEP - Calc-R (mbar/m): 0.268375 hPa/m; Calc-Velocitiy (m/s): 0.578458 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 648 | 125 | 139.7 | 131.7 | 28345.2 | 28368.4 | DN 125 | 139.7 x 4 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52 | Pset_MEP - Calc-R (mbar/m): 0.268375 hPa/m; Calc-Velocitiy (m/s): 0.578458 m/s
Rohr DIN EN 10220 | EG_Verwaltung_FFB | 388 | 125 | 139.7 | 131.7 | 28345.2 | 28368.4 | DN 125 | 139.7 x 4 | H_Kaltwasser_VL | 02d68179-ed5d-4232-b562-46366b7c6b07/1519ad10-f668-47e1-bd8e-1af201202a52 | Pset_MEP - Calc-R (mbar/m): 0.268375 hPa/m; Calc-Velocitiy (m/s): 0.578458 m/s

# IfcFlowSegment: Systemrohr CrTi (608)
Description: Systemrohr CrTi
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Systemrohr CrTi; Tech-Catalog: Geberit; Tech-Product type: Systemrohr CrTi; Tech-Manufacturer: Geberit
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
2 x Systemrohr CrTi | Wartung_FFB | 2744 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
Systemrohr CrTi | Wartung_FFB | 264.725 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
Systemrohr CrTi | Wartung_FFB | 651.246 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
Systemrohr CrTi | Wartung_FFB | 4047.92 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
2 x Systemrohr CrTi | Wartung_FFB | 2744 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
Systemrohr CrTi | Wartung_FFB | 494.611 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
Systemrohr CrTi | Wartung_FFB | 4004.56 | 20 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | -
Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 2241.42 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 2137.32 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 335.587 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 123.201 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 3450 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 4135 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 2787.77 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 1967.73 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 570 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 1177.2 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 459 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 1552.94 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 894.578 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 219.432 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 2900 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 459 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 1552.94 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 604.578 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 229.432 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 2900 | 20 | 40 | 42 | 39 | 2529.79 | 2531.87 | 1.16572 | 0.588735 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 4135 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 2587.77 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 1667.73 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 570 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 1477.2 | 20 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | -
Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 2141.42 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 2137.32 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 145.587 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 133.201 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
Systemrohr CrTi | Wartung_FFB | 3450 | 20 | 40 | 42 | 39 | 2213.57 | 2215.38 | 0.9223 | 0.515143 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | -
2 x Systemrohr CrTi | Wartung_FFB | 1595 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 5995.33 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 151 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 4672.13 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 259.163 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
2 x Systemrohr CrTi | Wartung_FFB | 1595 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 5972.33 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 4372.13 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 259.163 | 20 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | -
Systemrohr CrTi | Wartung_FFB | 2935 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 172.365 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 628.043 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 2668.93 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 970 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 3881.59 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 2935 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 172.365 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 828.043 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 3301.85 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 970 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 4257.57 | 20 | 50 | 54 | 51 | 4427.14 | 4430.77 | 0.869727 | 0.602485 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | Wartung_FFB | 2144 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 3138.13 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
6 x Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 2571.37 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 1638 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 5707.4 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 555.412 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 2958 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 277.069 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 487.171 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 3572.05 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 1005 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 2958 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 277.069 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 311.188 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 2939.13 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 1005 | 20 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 2144 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 3338.13 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
6 x Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 2651.37 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 1638 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 5940.32 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 951.395 | 20 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | Wartung_FFB | 508.513 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1632 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
16 x Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1578.37 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 882 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 5761.1 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 732 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 941.773 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 232 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 3295.64 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
2 x Systemrohr CrTi | Wartung_FFB | 132 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 482.464 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 707.675 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 573.425 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 958 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 556.2 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 377 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 5271.93 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1832 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 5542.79 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 476.751 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 225.115 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1868.67 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 3890.76 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 282 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 704.5 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 658.193 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 401.021 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
16 x Systemrohr CrTi | Wartung_FFB | 6000 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 5471.93 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1832 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 5342.79 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 276.751 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
2 x Systemrohr CrTi | Wartung_FFB | 132 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 425.115 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1868.67 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 3890.76 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 282 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 404.5 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 448.193 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 391.021 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 958 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 116 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 1056.2 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 377 | 20 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | Wartung_FFB | 308.513 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1632 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 1408.37 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 882 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 5761.1 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 732 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 911.773 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 232 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 3295.64 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 582.464 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 497.675 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | Wartung_FFB | 563.425 | 20 | 25 | 28 | 25.6 | 589.327 | 589.81 | 0.679775 | 0.318302 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 245.252 | 19 | 65 | 76.1 | 73.1 | 11039.1 | 11048.2 | 0.786189 | 0.731244 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 917.454 | 19 | 65 | 76.1 | 73.1 | 6058.57 | 6063.54 | 0.271975 | 0.401328 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 4208.55 | 19 | 25 | 28 | 25.6 | 546.205 | 546.653 | 0.59635 | 0.295012 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 4208.55 | 19 | 25 | 28 | 25.6 | 546.205 | 546.653 | 0.59635 | 0.295012 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1167.45 | 19 | 65 | 76.1 | 73.1 | 6058.57 | 6063.54 | 0.271975 | 0.401328 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 197.997 | 19 | 32 | 35 | 32 | 1609.87 | 1611.19 | 1.35258 | 0.556486 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 197.995 | 19 | 32 | 35 | 32 | 1609.87 | 1611.19 | 1.35258 | 0.556486 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 273.924 | 19 | 65 | 76.1 | 73.1 | 9709.52 | 9717.48 | 0.626005 | 0.643171 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 347.053 | 19 | 25 | 28 | 25.6 | 646.822 | 647.353 | 0.798266 | 0.349356 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 347.053 | 19 | 25 | 28 | 25.6 | 646.822 | 647.353 | 0.798266 | 0.349356 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3773.96 | 19 | 20 | 22 | 19.6 | 431.215 | 431.569 | 1.40177 | 0.397324 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3427.04 | 19 | 20 | 22 | 19.6 | 431.215 | 431.569 | 1.40177 | 0.397324 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 252 | 19 | 32 | 35 | 32 | 1121.16 | 1122.08 | 0.719813 | 0.387553 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 1642.55 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2009.3 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 252 | 19 | 32 | 35 | 32 | 1121.16 | 1122.08 | 0.719813 | 0.387553 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 3037.97 | 19 | 40 | 42 | 39 | 2041.08 | 2042.76 | 0.800171 | 0.475002 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 3053.61 | 19 | 40 | 42 | 39 | 2041.08 | 2042.76 | 0.800171 | 0.475002 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 2386.21 | 19 | 32 | 35 | 32 | 1394.26 | 1395.4 | 1.05215 | 0.481957 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 5604.82 | 19 | 32 | 35 | 32 | 1020.54 | 1021.38 | 0.611382 | 0.352772 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 5604.82 | 19 | 32 | 35 | 32 | 1020.54 | 1021.38 | 0.611382 | 0.352772 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 2061.21 | 19 | 32 | 35 | 32 | 1394.26 | 1395.4 | 1.05215 | 0.481957 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 245.252 | 19 | 65 | 76.1 | 73.1 | 11039.1 | 11048.2 | 0.786189 | 0.731244 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 4370 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 795 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 545 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 362.002 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 608.674 | 19 | 65 | 76.1 | 73.1 | 9709.52 | 9717.48 | 0.626005 | 0.643171 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 2257 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 3224.51 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 495.768 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 3423.49 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 383.287 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 365 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 803.786 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 252 | 19 | 32 | 35 | 32 | 1638.62 | 1639.96 | 1.39511 | 0.566423 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 32 | 35 | 32 | 1638.62 | 1639.96 | 1.39511 | 0.566423 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 4372.93 | 19 | 32 | 35 | 32 | 1638.62 | 1639.96 | 1.39511 | 0.566423 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 2467.71 | 19 | 25 | 28 | 25.6 | 819.308 | 819.98 | 1.20208 | 0.442518 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 3280.45 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 801.718 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 481.397 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 453.587 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 99 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 99 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 453.587 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 308.57 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 901.718 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 3253.28 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 2452.06 | 19 | 25 | 28 | 25.6 | 819.308 | 819.98 | 1.20208 | 0.442518 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 252 | 19 | 32 | 35 | 32 | 1638.62 | 1639.96 | 1.39511 | 0.566423 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 32 | 35 | 32 | 1638.62 | 1639.96 | 1.39511 | 0.566423 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 3947.93 | 19 | 32 | 35 | 32 | 1638.62 | 1639.96 | 1.39511 | 0.566423 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 376.287 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
