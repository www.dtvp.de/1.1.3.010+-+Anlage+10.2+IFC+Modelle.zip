Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcFlowSegment: Systemrohr CrTi (608)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrTi | EG_Verwaltung_FFB | 518.473 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 242.641 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 650.414 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 889.136 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 139.83 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 214.394 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 199 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 199 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 214.394 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 339.83 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 789.136 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 897.708 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 318.036 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 190.231 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 190.231 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 518.036 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 797.708 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 4329 | 19 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 724 | 19 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 449.25 | 19 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 4370 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 795 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 545 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 362.002 | 19 | 50 | 54 | 51 | 4743.36 | 4747.25 | 0.982311 | 0.64552 | DN 50 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 4329 | 19 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 724 | 19 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 523 | 19 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 4280 | 19 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | 313.122
Systemrohr CrTi | EG_Verwaltung_FFB | 645 | 19 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | 313.122
Systemrohr CrTi | EG_Verwaltung_FFB | 405 | 19 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | 313.122
Systemrohr CrTi | EG_Verwaltung_FFB | 4280 | 19 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | 313.122
Systemrohr CrTi | EG_Verwaltung_FFB | 645 | 19 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | 313.122
Systemrohr CrTi | EG_Verwaltung_FFB | 405 | 19 | 100 | 108 | 104 | 14388.2 | 14400 | 0.233471 | 0.470873 | DN 100 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/2b44bfcb-ee6c-4487-88ea-859ce2151a28 | 49611 | 313.122
Systemrohr CrTi | EG_Verwaltung_FFB | 4329 | 19 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 724 | 19 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 449.25 | 19 | 65 | 76.1 | 73.1 | 6094.5 | 6099.5 | 0.274823 | 0.403708 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 4329 | 19 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 724 | 19 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 523 | 19 | 65 | 76.1 | 73.1 | 6295.73 | 6300.9 | 0.291014 | 0.417038 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119

# IfcFlowStorageDevice: Pufferspeicher
In: EG_Verwaltung_FFB
Description: Pufferspeicher
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Pufferspeicher; Info: 3400 kg

# IfcFlowTerminal: Verbraucher (2)
In: Wartung_FFB
Description: Verbraucher

# IfcProxy: RLT-Anlage 01 - Spülküche, Diatküche
Description: RLT-Anlage 01 - Spülküche, Diatküche; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage 01 - Spülküche, Diatküche

# IfcProxy: RLT-Anlage 02 - Lager / Werkstatt
Description: RLT-Anlage 02 - Lager / Werkstatt; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage 02 - Lager / Werkstatt

# IfcProxy: RLT-Anlage 03 - Büro + Aufenthaltsräume
Description: RLT-Anlage 03 - Büro + Aufenthaltsräume; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage 03 - Büro + Aufenthaltsräume

# IfcProxy: RLT-Anlage 04 - Halle
Description: RLT-Anlage 04 - Halle; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage 04 - Halle

# IfcProxy: RLT-Anlage 05 - Technik
Description: RLT-Anlage 05 - Technik; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage 05 - Technik

# IfcProxy: RLT-Anlage Kaltarbeitsplätze
Description: RLT-Anlage Kaltarbeitsplätze; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage Kaltarbeitsplätze

# IfcProxy: RLT-Anlage Warmarbeitsplätze
Description: RLT-Anlage Warmarbeitsplätze; ProxyType: PRODUCT
Pset_MEP - Name: RLT-Anlage Warmarbeitsplätze

# IfcProxy: SLK Wandgerät (2)
Description: SLK Wandgerät; ProxyType: PRODUCT
Pset_MEP - Name: SLK Wandgerät

# IfcProxy: Zentrale
Description: Zentrale; ProxyType: PRODUCT
Pset_MEP - Name: Zentrale
