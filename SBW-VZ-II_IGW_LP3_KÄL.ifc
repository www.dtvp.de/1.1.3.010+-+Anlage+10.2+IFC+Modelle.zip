Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcFlowSegment: Systemrohr CrTi (608)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-Mass flow heating (kg/h) (kg/hour) | Calc-Volumetric flow heating (l/h) (mm3/hour) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrTi | EG_Verwaltung_FFB | 365 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 894.429 | 19 | 50 | 54 | 51 | 3679.7 | 3682.72 | 0.628005 | 0.500767 | DN 50 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/a357f1ca-6d7e-461a-8d8b-58ea3110bdb7 | 49108 | 313.118
Systemrohr CrTi | EG_Verwaltung_FFB | 2257 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 3024.51 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 670.768 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 3105.49 | 19 | 65 | 76.1 | 73.1 | 6920.99 | 6926.67 | 0.343909 | 0.458456 | DN 65 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/6aab0d9d-e837-4d54-82c3-4bd7c74a8e01 | 49609 | 313.119
Systemrohr CrTi | EG_Verwaltung_FFB | 514.999 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 575 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 1545 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 223.004 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 5993.77 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 47 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 92 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3686.49 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 332 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 739.626 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 297.829 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 824.602 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2829.57 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 170.89 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 232 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 224.841 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 409.187 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 666 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 5892.77 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 92 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3718.49 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 332 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 857.624 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 165.829 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 492.602 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2761.57 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 82.8905 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 232 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 429.841 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 414.187 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 666 | 19 | 25 | 28 | 25.6 | 718.691 | 719.281 | 0.957812 | 0.388174 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 515.003 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 575 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 1545 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 223.002 | 19 | 40 | 42 | 39 | 2788.52 | 2790.81 | 1.38328 | 0.648946 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 122.998 | 19 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 2073.05 | 19 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 186 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 532 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2562.68 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1307.54 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3448.32 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3254.49 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 494.596 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 260.142 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 224.004 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 564 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3217.21 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 594.596 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 105.522 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 224.004 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 564 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 186 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 532 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3162.68 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1407.54 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3440.22 | 19 | 25 | 28 | 25.6 | 891.177 | 891.908 | 1.39109 | 0.481335 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 118 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 316.105 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 272.131 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 394 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 118 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 508.004 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 272.131 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 394 | 19 | 20 | 22 | 19.6 | 445.588 | 445.954 | 1.48329 | 0.410569 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2073.05 | 19 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 123.005 | 19 | 32 | 35 | 32 | 1178.65 | 1179.62 | 0.785203 | 0.407427 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 1335.82 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3263.64 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 79 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
4 x Systemrohr CrTi | EG_Verwaltung_FFB | 78 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 891.151 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 318.528 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 1557.34 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 152 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
4 x Systemrohr CrTi | EG_Verwaltung_FFB | 78 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 806.098 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 216.131 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 1564.73 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 152 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 767.177 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 166.71 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 321.777 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 954.626 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 366.125 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 529.756 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 202.316 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 110.78 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 1874.66 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 99.2747 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 202.316 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 260.78 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 1467.27 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 108.752 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 388.386 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 2437.69 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 155 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 155 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 2430.3 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 228.909 | 19 | 15 | 18 | 16 | 215.607 | 215.784 | 1.11239 | 0.298117 | DN 15 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/acd3fc3c-5a46-497f-bbd5-b6d95a5d59d7 | 49103 | 313.113
Systemrohr CrTi | EG_Verwaltung_FFB | 1641.26 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 3596.03 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 79 | 19 | 25 | 28 | 25.6 | 862.429 | 863.137 | 1.31404 | 0.465809 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 227.498 | 19 | 40 | 42 | 39 | 2378.87 | 2380.82 | 1.04642 | 0.553611 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 40 | 42 | 39 | 2378.87 | 2380.82 | 1.04642 | 0.553611 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 550.209 | 19 | 40 | 42 | 39 | 2378.87 | 2380.82 | 1.04642 | 0.553611 | DN 40 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 147 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2386 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 5462.38 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1223.65 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 374 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 213.03 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2292.42 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 802.222 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 1302.22 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2177.42 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 213.03 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 374 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 553.031 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 647.599 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2972.05 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 347 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 548.031 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 342.599 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2657.05 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 347 | 19 | 25 | 28 | 25.6 | 510.271 | 510.689 | 0.530453 | 0.275603 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1115.67 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 5479.38 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1967.87 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 147 | 19 | 25 | 28 | 25.6 | 883.99 | 884.715 | 1.37165 | 0.477454 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 102.498 | 19 | 40 | 42 | 39 | 2378.87 | 2380.82 | 1.04642 | 0.553611 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 40 | 42 | 39 | 2378.87 | 2380.82 | 1.04642 | 0.553611 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 776.322 | 19 | 40 | 42 | 39 | 2378.87 | 2380.82 | 1.04642 | 0.553611 | DN 40 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/ffa519cf-85cc-4b84-9cc8-7dcaeb868e9e | 49107 | 313.117
Systemrohr CrTi | EG_Verwaltung_FFB | 5246.33 | 19 | 32 | 35 | 32 | 1494.88 | 1496.1 | 1.18825 | 0.516737 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 263 | 19 | 32 | 35 | 32 | 1494.88 | 1496.1 | 1.18825 | 0.516737 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 134 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 225.637 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 368.868 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 1192.91 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 45 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 134 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 225.637 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 223.153 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 1219.02 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 45 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 523.153 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3263.27 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 668.868 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3689.38 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 234 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 176.406 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 398.523 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 1184.69 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 216 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 216 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 1210.8 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 177.485 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 176.406 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 234 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 48 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3255.05 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 477.485 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 698.523 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3681.16 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 48 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 263 | 19 | 32 | 35 | 32 | 1494.88 | 1496.1 | 1.18825 | 0.516737 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 5232.62 | 19 | 32 | 35 | 32 | 1494.88 | 1496.1 | 1.18825 | 0.516737 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 338 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 5766.07 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 491.917 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 215.87 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 74 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 74 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 215.87 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 691.917 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 5841.07 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 338 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 5817.36 | 19 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 127 | 19 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 3258.79 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2310.63 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 113.878 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 302.813 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 182.857 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 374 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2983.79 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2010.63 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 229.523 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 252.813 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 67.2116 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 374 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 5917.36 | 19 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 127 | 19 | 32 | 35 | 32 | 1667.36 | 1668.73 | 1.43822 | 0.57636 | DN 32 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/36eddceb-1848-4297-932a-d7c5abfe5d4e | 49106 | 313.116
Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 303.836 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1921.77 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 1285.34 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 213.983 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 285.62 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 174 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 1685.34 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 413.983 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
2 x Systemrohr CrTi | EG_Verwaltung_FFB | 285.62 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
3 x Systemrohr CrTi | EG_Verwaltung_FFB | 174 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 6000 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 703.836 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 2021.77 | 19 | 25 | 28 | 25.6 | 747.439 | 748.052 | 1.02513 | 0.403701 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 168.595 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2488.48 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 145 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 168.595 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2188.48 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 145 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 145 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2471.67 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 167.791 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 174 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 174 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 168.595 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 2170.86 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 145 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 148 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3059.11 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 148 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 3459.11 | 19 | 20 | 22 | 19.6 | 373.719 | 374.026 | 1.0958 | 0.344348 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 4888.28 | 19 | 25 | 28 | 25.6 | 819.308 | 819.98 | 1.20208 | 0.442518 | DN 25 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 232.443 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 269.133 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 632.491 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
4 x Systemrohr CrTi | EG_Verwaltung_FFB | 48 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
4 x Systemrohr CrTi | EG_Verwaltung_FFB | 48 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 592.138 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 469.133 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 232.443 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 4828.63 | 19 | 25 | 28 | 25.6 | 819.308 | 819.98 | 1.20208 | 0.442518 | DN 25 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/9708f2e8-43db-49ed-b870-7db3bca8055c | 49105 | 313.115
Systemrohr CrTi | EG_Verwaltung_FFB | 244.228 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 312.42 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 612.07 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 244.228 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 112.42 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 652.423 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_VL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 610.061 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 415.467 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
Systemrohr CrTi | EG_Verwaltung_FFB | 518.473 | 19 | 20 | 22 | 19.6 | 273.103 | 273.327 | 0.64039 | 0.251639 | DN 20 6m | H_Kaltwasser_RL | 5992b63d-acee-48f0-9c27-8831f02f2006/96291888-ea14-4664-8f9b-6a16bf1cf2ed | 49104 | 313.114
