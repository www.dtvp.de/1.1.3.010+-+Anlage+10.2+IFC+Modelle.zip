Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Stahlrohr nach DIN 2448 (1604)
Name | In | Tech-DN | Geom-Outer diameter (mm) (mm) | Pset_MEP, Geom-Length (mm) (mm) | Floor | Floor No. | Building = Building No.
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 8820.91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1128.07 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 17075 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 17273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 26190 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 8799 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 16966 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
14 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 443.881 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 15007 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 14007 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Geom-Length (mm): 1850 m
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 350 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 31957 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
7 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 32098 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 22060 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 9942 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 700 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 47532 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 1767 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 214.618 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 774.651 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 272.423 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 41586 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
9 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1469 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 352.797 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 5622 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 496.151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
20 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 129.698 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
9 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2513 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 14740 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 23274.4 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 5112.54 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 211.1 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2572 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 235.625 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 12125 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10818.1 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 129.695 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 5196.59 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 5637.76 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10376.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 3178.28 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10468.7 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 17918.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 18725.8 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 9661.18 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 9547 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1160.47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2377.79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 30942.6 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 9749 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1331.02 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1920.5 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 31249.1 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 934.224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1962.88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 562.759 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 31206.7 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 6580 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 660.858 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 12809.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2065.26 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 5272.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 5598.12 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2552.56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 749.742 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1821.87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2976.57 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1458.07 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 422.807 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1848.64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10112.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1461.87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 440.701 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1892.85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 27614 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10911.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 265.395 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2119.14 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 13515 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 423.875 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2137.14 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 15317.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1121.54 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 234.183 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2184.71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 19740.1 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1068.75 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 406.438 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2210.71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 8617.59 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 3741 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 522.509 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2121.47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1138.24 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 432.884 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2103.47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 14448.6 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 25106.5 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1556.02 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 526.418 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1735.38 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2408.37 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 493.586 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2206.62 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 38304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2545.34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 687.343 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1863.29 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1294.55 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 650.758 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2197.31 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 27018 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1441.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 975.945 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1872.72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 6119.25 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10417.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 574.544 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1862.57 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 17408.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1728.56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 7879.87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1692.78 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1422 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 10292.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 207.222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 2162.39 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 17175.5 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1987.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 7605.58 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1987.37 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1324 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 5665 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 401.595 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 7201.71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 30052.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 5660 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 379.91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 7161.01 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 30046.4 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 11047.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 178.974 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1430.1 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 11059.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 72.6097 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1448.1 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 19399 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 19251.2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 4108.63 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 339.868 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1678.84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 11094.5 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 12820.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 486.404 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1760.83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2300.82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 6100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 137.827 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 6751.97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 29887.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 25250.6 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
16 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 159.781 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 808.08 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 6531.11 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 834.967 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 21665.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 773 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 6566 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1874 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 57.7692 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 29224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 13882.8 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 321.867 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1334.04 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 16511.7 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 276.331 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 992.366 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 16853.4 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 13825.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 315.07 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1031.67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 16870.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 5828 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 5528 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1873.94 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
10 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 16.4923 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 387
14 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 806.176
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 29478
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 15003.1
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 27985.9
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 462.176
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 7421.14
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 15056.9
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 4884.52
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2316.35
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 6146.9
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1883.41
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 27977.9
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 19325
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 196.656
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 955.3
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 22586.7
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 9129.82
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 278.262
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 577.122
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 33212.1
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 189.482
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 593.805
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 159
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 10538.2
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 263.315
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 641.41
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 18844.2
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 363.241
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 104
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 6865.83
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 354.179
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1134.64
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 10385
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 9121.82
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 179.963
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 550.122
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 33195.1
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 3572.23
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 160.745
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 923.992
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 16977.7
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2274.29
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 135.918
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 623.41
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10521.2
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2025.35
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 280.716
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 794.147
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 5664.1
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 414.752
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 4237.28
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 8155.59
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 363.806
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2424.78
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 20134.2
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | Pset_MEP - Geom-Length (mm): 857 m
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 353.732
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1542
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 2000 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 24315
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 6668.89
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 28846
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 318
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 213.801
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 2258
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 100 | 114.3 | 550
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 100 | 114.3 | 2538.2
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 100 | 114.3 | 4509.16
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 100 | 114.3 | 656.195
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 100 | 114.3 | 825.81
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 100 | 114.3 | 568.835
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 250 | 273 | 3000
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 1300
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 412.049
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 409.075
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 495.075
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 1024.1
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 100
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 880.723
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 2027.39
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 749.81
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 530.835
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 2656.77
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 93.9884
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 279.915
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 2357.09
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 2813.43
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 253
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 84.3418
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 73.3726
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 65.9167
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1427.95
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1011.59
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 54.2769
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 904.995
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 85.5471
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 859.212
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 327.703
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 292.184
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1305.98
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 135.557
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 4680.94
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 10206.7
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 353.539
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 3145.48
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 500 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 1271 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 200
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 8100
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 165.014
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 808.129
8 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 60
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 448.588

# IfcFlowStorageDevice: Drucklufttank
In: EG_Verwaltung_FFB
Description: Drucklufttank
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Drucklufttank; Info: 300 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowStorageDevice: Quader (6)
In: EG_Verwaltung_FFB
Description: Quader
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Quader; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: IfcObject (1076)
In: Wartung_FFB
Description: IfcObject
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: IfcObject

# IfcProxy: Anlage Sanitär (2)
Description: Anlage Sanitär; ProxyType: PRODUCT
Pset_MEP - Name: Anlage Sanitär; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: FreierVerbraucherSanitaer (4)
Description: FreierVerbraucherSanitaer; ProxyType: PRODUCT
Pset_MEP - Name: FreierVerbraucherSanitaer; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No. | Floor | Floor No.
FreierVerbraucherSanitaer | 2 | EG_Verwaltung_FFB | 0
FreierVerbraucherSanitaer | 6 | Grundleitungsebene | -1
FreierVerbraucherSanitaer | 8 | Grundleitungsebene | -1
FreierVerbraucherSanitaer | 4 | Grundleitungsebene | -1

# IfcProxy: Netzendpunkt Sanitär (22)
Description: Netzendpunkt Sanitär; ProxyType: PRODUCT
