Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2026-07-17T10:14:55+02:00
Author: Bra
Organization: IGW
Written by: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)
Made in: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)

# IfcSite: Projektstandort, Default
RefLatitude: 49, 0, 3571; RefLongitude: 12, 15, -2; RefElevation: 0 m

# IfcSite: Pyramidenstumpf (8)
Description: Pyramidenstumpf
Pset_Basis - Name: Pyramidenstumpf; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Floor | Floor No.
2 x Pyramidenstumpf | Wartung_FFB | 2
4 x Pyramidenstumpf | EG_Verwaltung_FFB | 0
2 x Pyramidenstumpf | Grundleitungsebene | -1

# IfcBuilding: Gebäude, Speiseverteilzentrum SBW VZ II
Description: Speiseverteilzentrum SBW VZ II

# IfcBuildingStorey: Geschoss (4)
In: Speiseverteilzentrum SBW VZ II
Name | Description | Elevation (m)
Wartung_FFB | 2 | 7.1307
UK Thermische Hülle | 1 | 6.2307
EG_Verwaltung_FFB | 0 | 0.115653
Grundleitungsebene | -1 | -1.884

# IfcBuildingElementProxy: IfcProxy (49)
Description: IfcProxy
Name | In
4 x IfcProxy | Wartung_FFB
42 x IfcProxy | EG_Verwaltung_FFB
3 x IfcProxy | Grundleitungsebene

# IfcBuildingElementProxy: Revisionswolke (26)
In: EG_Verwaltung_FFB
Description: Revisionswolke

# IfcDistributionElement: Feuerwehreinspeisung
In: EG_Verwaltung_FFB
Description: Feuerwehreinspeisung
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Feuerwehreinspeisung; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Kompressor (2)
In: EG_Verwaltung_FFB
Description: Kompressor
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Kompressor; Info: 75 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Regelstr.
In: EG_Verwaltung_FFB
Description: Regelstr.
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Regelstr.; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Sprinklerpumpe (2)
In: EG_Verwaltung_FFB
Description: Sprinklerpumpe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Sprinklerpumpe; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowController: Absperrarmatur Durchgang (4)
Description: Absperrarmatur Durchgang
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Absperrarmatur Durchgang; Tech-Medium: S_Feuerloescherwasser; Tech-Product item: Lokales Bauteil
Name | In | Tech-DN | Floor | Floor No. | Building = Building No.
Absperrarmatur Durchgang | EG_Verwaltung_FFB | 140 | Pset_MEP - Tech-Insulation thickness (mm): 0 mm
3 x Absperrarmatur Durchgang | Grundleitungsebene | 125 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II

# IfcFlowController: Absperrklappe (29)
Description: Absperrklappe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-PN: 16; Name: Absperrklappe; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Tech-DN | Geom-Outer diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Connection type (Inner thread=2, flange=3) | Floor | Floor No.
16 x Absperrklappe | Wartung_FFB | 100 | 220 | 240 | 3 | Wartung_FFB | 2
3 x Absperrklappe | EG_Verwaltung_FFB | 80 | 200 | 205 | 3 | EG_Verwaltung_FFB | 0
2 x Absperrklappe | EG_Verwaltung_FFB | 150 | 285 | 480 | 2 | EG_Verwaltung_FFB | 0
8 x Absperrklappe | EG_Verwaltung_FFB | 125 | 250 | 400 | 2 | EG_Verwaltung_FFB | 0

# IfcFlowController: Pumpstation
In: EG_Verwaltung_FFB
Description: Pumpstation
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Pumpstation; Info: Löschwasser; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: Abzweigstück (1619)
Description: Abzweigstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material: nach DIN 2615; Name: Abzweigstück
Name | In | Tech-DN1 = Tech-DN2 | Tech-DN3 | Geom-Outer diameter1 (mm) (mm) = Geom-Outer diameter2 (mm) (mm) | Geom-Outer diameter3 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Length outlet (mm) (mm) | Floor | Floor No. | Building = Building No.
288 x Abzweigstück | Wartung_FFB | 100 | 40 | 114.3 | 48.3 | 210 | 86 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
4 x Abzweigstück | Wartung_FFB | 150 | 100 | 168.3 | 114.3 | 286 | 130 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
6 x Abzweigstück | Wartung_FFB | 100 | 100 | 114.3 | 114.3 | 210 | 105 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
1076 x Abzweigstück | Wartung_FFB | 40 | 20 | 48.3 | 26.9 | 114 | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück | Wartung_FFB | 150 | 150 | 168.3 | 168.3 | 286 | 143
Abzweigstück | EG_Verwaltung_FFB | 150 | 80 | 168.3 | 88.9 | 286 | 124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Abzweigstück | EG_Verwaltung_FFB | 150 | 32 | 168.3 | 42.4 | 364 | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
46 x Abzweigstück | EG_Verwaltung_FFB | 80 | 32 | 88.9 | 42.4 | 172 | 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
13 x Abzweigstück | EG_Verwaltung_FFB | 150 | 25 | 168.3 | 33.7 | 350 | 175 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Abzweigstück | EG_Verwaltung_FFB | 150 | 125 | 168.3 | 139.7 | 286 | 137 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück | EG_Verwaltung_FFB | 125 | 125 | 139.7 | 139.7 | 248 | 124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
77 x Abzweigstück | EG_Verwaltung_FFB | 125 | 40 | 139.7 | 48.3 | 330 | 165 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
59 x Abzweigstück | EG_Verwaltung_FFB | 125 | 32 | 139.7 | 42.4 | 314 | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
16 x Abzweigstück | EG_Verwaltung_FFB | 32 | 32 | 42.4 | 42.4 | 96 | 48 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Abzweigstück | EG_Verwaltung_FFB | 125 | 80 | 139.7 | 88.9 | 248 | 111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
18 x Abzweigstück | EG_Verwaltung_FFB | 80 | 40 | 88.9 | 48.3 | 172 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Abzweigstück | EG_Verwaltung_FFB | 150 | 150 | 168.3 | 168.3 | 286 | 143 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Abzweigstück | EG_Verwaltung_FFB | 150 | 150 | 168.3 | 168.3 | 286 | 143
Abzweigstück | EG_Verwaltung_FFB | 150 | 125 | 168.3 | 139.7 | 286 | 137

# IfcFlowFitting: Bogen 90° 2M (41)
In: EG_Verwaltung_FFB
Description: Bogen 90° 2M
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Bogen 90° 2M; Tech-Medium: S_Medizinaldruckluft_4.0_Bar; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Bogen 90° 2M; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN | Info | Tech-Product item
12 x Bogen 90° 2M | 20 | DN 20 | 02d68179-ed5d-4232-b562-46366b7c6b07/23f6d4b6-a84e-4d73-a661-f419118d2b44
2 x Bogen 90° 2M | 12 | DN 12 | 02d68179-ed5d-4232-b562-46366b7c6b07/5f3d01e8-cd1f-4ed8-a24c-be095bc763e0
27 x Bogen 90° 2M | 10 | DN 10 | 02d68179-ed5d-4232-b562-46366b7c6b07/caf7ceba-1a41-4235-a8ce-dcc935a84e2c

# IfcFlowFitting: Bogen 90° PE-MDX (15)
Description: Bogen 90° PE-MDX
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 10 mm; Name: Bogen 90° PE-MDX; Tech-Medium: S_Feuerloescherwasser; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Bogen 90° PE-MDX; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-DN = Info | Tech-Product item
2 x Bogen 90° PE-MDX | EG_Verwaltung_FFB | 140 | 02d68179-ed5d-4232-b562-46366b7c6b07/67356122-1432-4d12-aa07-0dd61457bff8
6 x Bogen 90° PE-MDX | EG_Verwaltung_FFB | 32 | 02d68179-ed5d-4232-b562-46366b7c6b07/162696d0-b915-43c6-8598-b22ce3e24b9b
7 x Bogen 90° PE-MDX | Grundleitungsebene | 140 | 02d68179-ed5d-4232-b562-46366b7c6b07/67356122-1432-4d12-aa07-0dd61457bff8 | Pset_MEP - Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: Doppelabzweig (Kreuzstück) (42)
In: EG_Verwaltung_FFB
Description: Doppelabzweig (Kreuzstück)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 90 rad; Tech-Material: nach DIN 2615; Name: Doppelabzweig (Kreuzstück); Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Tech-DN1 = Tech-DN2 | Tech-DN3 | Geom-Outer diameter1 (mm) (mm) = Geom-Outer diameter2 (mm) (mm) | Geom-Outer diameter3 (mm) (mm) | Geom-Length (mm) (mm)
Doppelabzweig (Kreuzstück) | 125 | 80 | 139.7 | 88.9 | 248
21 x Doppelabzweig (Kreuzstück) | 150 | 40 | 168.3 | 48.3 | 380
20 x Doppelabzweig (Kreuzstück) | 150 | 32 | 168.3 | 42.4 | 364

# IfcFlowFitting: Flansch
In: EG_Verwaltung_FFB
Description: Flansch
Pset_MEP - Tech-DN: 125; Geom-Outer diameter (mm): 250 mm; Geom-Depth: 55 m; Tech-Material: nach DIN 2627; Tech-PN: 16; Name: Flansch
Pset_PipeFittingTypeCommon - PressureClass: 16
Pset_PipeConnectionFlanged - FlangeStandard: 2627; FlangeDiameter: 125; NumberOfBoltholes: 8; BoltSize: M16

# IfcFlowFitting: Kupplung PE-MDX (59)
In: Grundleitungsebene
Description: Kupplung PE-MDX
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN1: 140; Tech-DN2: 140; Tech-Insulation thickness (mm): 10 mm; Name: Kupplung PE-MDX; Info: 140; Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II; Tech-Medium: S_Feuerloescherwasser; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Kupplung PE-MDX; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/eec60d2c-4d68-4f1b-9406-ce8620c5a820; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -

# IfcFlowFitting: Muffe (18)
In: EG_Verwaltung_FFB
Description: Muffe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Muffe; Tech-Medium: S_Medizinaldruckluft_4.0_Bar; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Muffe; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN1 = Tech-DN2 | Info | Tech-Product item
6 x Muffe | 15 | DN 15 | 02d68179-ed5d-4232-b562-46366b7c6b07/de99a081-dbc8-494d-8580-625a9585cdf7
10 x Muffe | 20 | DN 20 | 02d68179-ed5d-4232-b562-46366b7c6b07/4bae0741-4e4f-422d-9dcf-e8c002757d1f
Muffe | 12 | DN 12 | 02d68179-ed5d-4232-b562-46366b7c6b07/c7bd4111-4e06-4928-b1a1-b7d38c46c4a6
Muffe | 10 | DN 10 | 02d68179-ed5d-4232-b562-46366b7c6b07/d34b556f-5445-457c-8f65-7d8a5be67aa0

# IfcFlowFitting: Reduzierung Kupfer Nippel-Muffe (2)
In: EG_Verwaltung_FFB
Description: Reduzierung Kupfer Nippel-Muffe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN1: 15; Tech-DN2: 12; Name: Reduzierung Kupfer Nippel-Muffe; Info: DN 15 - 12; Tech-Medium: S_Medizinaldruckluft_4.0_Bar; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Reduzierung Kupfer Nippel-Muffe; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/7b3ece53-2c47-4ce2-b61b-1df27806fe35; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -

# IfcFlowFitting: Rohrbogen (1331)
Description: Rohrbogen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material: nach DIN 2605; Name: Rohrbogen
Name | In | Tech-DN1 = Tech-DN2 | Geom-Outer diameter1 (mm) (mm) = Geom-Outer diameter2 (mm) (mm) | Floor | Floor No. | Building = Building No.
777 x Rohrbogen | Wartung_FFB | 40 | 48.3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
18 x Rohrbogen | Wartung_FFB | 100 | 114.3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
9 x Rohrbogen | Wartung_FFB | 150 | 168.3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
8 x Rohrbogen | Wartung_FFB | 100 | 114.3
20 x Rohrbogen | EG_Verwaltung_FFB | 150 | 168.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrbogen | EG_Verwaltung_FFB | 25 | 33.7 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
25 x Rohrbogen | EG_Verwaltung_FFB | 125 | 139.7 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
170 x Rohrbogen | EG_Verwaltung_FFB | 32 | 42.4 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Rohrbogen | EG_Verwaltung_FFB | 80 | 88.9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
220 x Rohrbogen | EG_Verwaltung_FFB | 40 | 48.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
44 x Rohrbogen | EG_Verwaltung_FFB | 40 | 48.3
5 x Rohrbogen | EG_Verwaltung_FFB | 150 | 168.3
18 x Rohrbogen | EG_Verwaltung_FFB | 32 | 42.4
8 x Rohrbogen | EG_Verwaltung_FFB | 125 | 139.7
5 x Rohrbogen | EG_Verwaltung_FFB | 100 | 114.3

# IfcFlowFitting: T-Stück (11)
In: EG_Verwaltung_FFB
Description: T-Stück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: T-Stück; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN1 = Tech-DN2 = Tech-DN3 | Info | Tech-Medium | Tech-Product item
T-Stück | 15 | DN 15 | S_Druckluft | 02d68179-ed5d-4232-b562-46366b7c6b07/756e95ff-43ea-446d-a70f-b12dfac48e5e
3 x T-Stück | 10 | DN 10 | S_Kaltwasser | 02d68179-ed5d-4232-b562-46366b7c6b07/16f134a7-23c1-47a5-9cc1-a182d8906865
6 x T-Stück | 10 | DN 10 | S_Druckluft | 02d68179-ed5d-4232-b562-46366b7c6b07/16f134a7-23c1-47a5-9cc1-a182d8906865
T-Stück | 12 | DN 12 | S_Druckluft | 02d68179-ed5d-4232-b562-46366b7c6b07/3ce607ec-4f86-4980-8942-ca5fe66f4bd6

# IfcFlowFitting: T-Stück PE-MDX (3)
Description: T-Stück PE-MDX
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN1: 140; Tech-DN2: 140; Tech-DN3: 140; Name: T-Stück PE-MDX; Info: 140; Tech-Medium: S_Feuerloescherwasser; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück PE-MDX; Tech-Product item: 02d68179-ed5d-4232-b562-46366b7c6b07/550eabe9-8729-4dd4-8cb4-e6ca24107dac; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Tech-Insulation thickness (mm) (mm) | Floor | Floor No. | Building = Building No.
T-Stück PE-MDX | EG_Verwaltung_FFB | 20
2 x T-Stück PE-MDX | Grundleitungsebene | 10 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: T-Stück, reduziert (4)
In: EG_Verwaltung_FFB
Description: T-Stück, reduziert
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN2: 10; Tech-Insulation thickness (mm): 0 mm; Name: T-Stück, reduziert; Tech-Medium: S_Druckluft; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück, reduziert; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN1 | Tech-DN3 | Info | Tech-Product item
3 x T-Stück, reduziert | 12 | 10 | DN 12 - 10 - 10 | 02d68179-ed5d-4232-b562-46366b7c6b07/abdd8f46-f26f-4c02-aa42-7dcd033ad7b7
T-Stück, reduziert | 20 | 20 | DN 20 - 20 - 10 | 02d68179-ed5d-4232-b562-46366b7c6b07/6a4822f1-fcf2-405c-8995-bfb1c39fb425

# IfcFlowFitting: T-Stück, reduziert Abgang (6)
In: EG_Verwaltung_FFB
Description: T-Stück, reduziert Abgang
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN1: 20; Tech-DN2: 20; Tech-Insulation thickness (mm): 0 mm; Name: T-Stück, reduziert Abgang; Tech-Medium: S_Druckluft; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: T-Stück, reduziert Abgang; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Tech-DN3 | Info | Tech-Product item
T-Stück, reduziert Abgang | 15 | DN 20 - 15 | 02d68179-ed5d-4232-b562-46366b7c6b07/5dc43e2a-d219-4def-8fe1-799daf0d4e62
5 x T-Stück, reduziert Abgang | 10 | DN 20 - 10 | 02d68179-ed5d-4232-b562-46366b7c6b07/8f24b005-8d59-4ed0-9dfe-6e5500f8f68e

# IfcFlowFitting: Übergangsstück (3)
Description: Übergangsstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Übergangsstück
Name | In | Tech-DN1 | Tech-DN2 | Geom-Outer diameter1 (mm) (mm) | Geom-Outer diameter2 (mm) (mm) | Geom-Length (mm) (mm) | Tech-Material | Floor | Floor No. | Building = Building No.
2 x Übergangsstück | Wartung_FFB | 100 | 150 | 114.3 | 168.3 | 140 | nach DIN 2616 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergangsstück | EG_Verwaltung_FFB | 140 | 32 | Pset_MEP - Tech-Insulation thickness (mm): 10 mm; Tech-Medium: S_Feuerloescherwasser; Tech-Product item: Lokales Bauteil

# IfcFlowSegment: Kupferrohr DIN EN 1057 (102)
In: EG_Verwaltung_FFB
Description: Kupferrohr DIN EN 1057
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Kupferrohr DIN EN 1057; Tech-Medium: S_Medizinaldruckluft_4.0_Bar; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Kupferrohr DIN EN 1057; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | Geom-Length (mm) (m) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Info | Tech-Product item
6 x Kupferrohr DIN EN 1057 | 5000 | 15 | 18 | 16 | 18 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/26f91c45-65a4-4682-bfa7-85cccdb10fc2
Kupferrohr DIN EN 1057 | 4838.24 | 15 | 18 | 16 | 18 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/26f91c45-65a4-4682-bfa7-85cccdb10fc2
2 x Kupferrohr DIN EN 1057 | 980 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
2 x Kupferrohr DIN EN 1057 | 857 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 3181.23 | 12 | 15 | 13 | 15 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/363bfab2-9bb4-4bd9-bbd4-494ccd1d9e5e
Kupferrohr DIN EN 1057 | 1235.51 | 12 | 15 | 13 | 15 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/363bfab2-9bb4-4bd9-bbd4-494ccd1d9e5e
Kupferrohr DIN EN 1057 | 1227.58 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 609.424 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 2069.8 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 1523.43 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
10 x Kupferrohr DIN EN 1057 | 5000 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1328.42 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1432.4 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 4300.22 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1565.99 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 734.16 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 2938.09 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1471 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1645.75 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1750.86 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 2856 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 325.305 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 3929.37 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 184.02 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1343.63 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
2 x Kupferrohr DIN EN 1057 | 1227.51 | 12 | 15 | 13 | 15 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/363bfab2-9bb4-4bd9-bbd4-494ccd1d9e5e
Kupferrohr DIN EN 1057 | 2906.7 | 12 | 15 | 13 | 15 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/363bfab2-9bb4-4bd9-bbd4-494ccd1d9e5e
3 x Kupferrohr DIN EN 1057 | 750 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
3 x Kupferrohr DIN EN 1057 | 472.25 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
21 x Kupferrohr DIN EN 1057 | 3999 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
6 x Kupferrohr DIN EN 1057 | 479.25 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
3 x Kupferrohr DIN EN 1057 | 477.25 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 5000 | 12 | 15 | 13 | 15 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/363bfab2-9bb4-4bd9-bbd4-494ccd1d9e5e
Kupferrohr DIN EN 1057 | 798.072 | 12 | 15 | 13 | 15 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/363bfab2-9bb4-4bd9-bbd4-494ccd1d9e5e
Kupferrohr DIN EN 1057 | 3477.9 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 1431.55 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 2342.54 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 2853.9 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 1447.96 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 1234.13 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 2787 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 3427.65 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 210.126 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 3988 | 20 | 22 | 20 | 22 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/d02b3fe1-70db-4523-9caf-2f9ca2ecee6c
Kupferrohr DIN EN 1057 | 2247.74 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 2629.09 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 5000 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 527.7 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 600.263 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 856.021 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 4077.49 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 277.649 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 333.162 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7
Kupferrohr DIN EN 1057 | 843.427 | 10 | 12 | 10 | 12 x 1 | 02d68179-ed5d-4232-b562-46366b7c6b07/e1c37b27-0786-44c7-a6a8-d7d1cf94d8c7

# IfcFlowSegment: Rohr
In: EG_Verwaltung_FFB
Description: Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 20 m; Tech-Insulation thickness (mm): 10 mm; Tech-DN: 140; Tech-Outside diameter (mm): 140 mm; Tech-Inside diameter (mm): 140 mm; Calc-R (mbar/m): 3.76855 hPa/m; Calc-Velocitiy (m/s): 2.38191 m/s; Calc-Design vol flow (l/s): 26.67 mm3/s; Calc-Total volumetric flow (l/s): 80.01 mm3/s; Name: Rohr; Tech-Medium: S_Feuerloescherwasser; Tech-Product item: Lokales Bauteil

# IfcFlowSegment: Rohr PE-MDX SDR 13.6 (79)
Description: Rohr PE-MDX SDR 13.6
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohr PE-MDX SDR 13.6; Tech-Medium: S_Feuerloescherwasser; Tech-Catalog: Generische Bauteile für Rohrleitungssysteme; Tech-Product type: Rohr PE-MDX SDR 13.6; Tech-Manufacturer: Generic; Tech-Order number: -; Tech-Standard Number: -
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN = Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Info 1 | Tech-Product item | Floor | Floor No. | Building = Building No.
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 1330.79 | 20 | 140 | 119.4 | 3.85517 | 2.41168 | 27.0033 | 81.01 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 2117.24 | 20 | 140 | 119.4 | 3.85517 | 2.41168 | 27.0033 | 81.01 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 920.602 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 80.01 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 939.998 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 80.01 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 62.3541 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 3372 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 3101.01 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 872 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 1426.88 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 141.621 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
Rohr PE-MDX SDR 13.6 | EG_Verwaltung_FFB | 936 | 10 | 32 | 27.2 | 12.6696 | 1.72097 | 1 | 1 | DN 32 | 32 x 2.4 | 02d68179-ed5d-4232-b562-46366b7c6b07/92292e3a-2795-4f26-b64b-136ee13c0f3c
7 x Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 5000 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 53.34 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 3132.31 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 53.34 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1850 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 80.01 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 4102.29 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 80.01 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
46 x Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 5000 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 3242.55 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1027.69 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 541.717 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
3 x Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1925 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1273.16 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1184.43 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1382.35 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 1985.41 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 2104.1 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
Rohr PE-MDX SDR 13.6 | Grundleitungsebene | 469.898 | 10 | 140 | 119.4 | 3.76855 | 2.38191 | 26.67 | 26.67 | DN 140 | 140 x 10.3 | 02d68179-ed5d-4232-b562-46366b7c6b07/754aed20-d40b-42c3-948f-1f1dfe478786 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II

# IfcFlowSegment: Stahlrohr nach DIN 2448 (1604)
Description: Stahlrohr nach DIN 2448
Pset_MEP - Tech-Material: Stahlrohr nach DIN 2448; Name: Stahlrohr nach DIN 2448
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Name | In | Tech-DN | Geom-Outer diameter (mm) (mm) | Pset_MEP, Geom-Length (mm) (mm) | Floor | Floor No. | Building = Building No.
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 31513 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 111100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 89396 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
36 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 7642 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
34 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 403 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
36 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 7690 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
36 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 617.479 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
71 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 10205 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
68 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 605.789 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
36 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 9231 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
143 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 601.203 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
71 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 10203 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
36 x Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 9232 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 8386 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 909 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 906 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 907 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 908 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 10174 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
256 x Stahlrohr nach DIN 2448 | Wartung_FFB | 20 | 26.9 | 250 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 3005 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 440.201 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 942 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 108 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 648 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 15893 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 90.1814 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 2611.33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 10115 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 63034 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 2000 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 1408.42
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 248.342
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 61886.7
2 x Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 7315.5
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 41361.4
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 41343.5
Stahlrohr nach DIN 2448 | Wartung_FFB | 100 | 114.3 | 61925.9
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 2940.48
4 x Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 1625.83
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 12781.1
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 386.314
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 7188.33
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 5979.68
Stahlrohr nach DIN 2448 | Wartung_FFB | 150 | 168.3 | 4360.12
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 1705 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | Wartung_FFB | 40 | 48.3 | 186
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 5307 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 3792 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 368 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 1113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 46926 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 46422 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 4439 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
9 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 5715 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
15 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 5693 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
11 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 25 | 33.7 | 525 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 25 | 33.7 | 1052 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 25 | 33.7 | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 25 | 33.7 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 11574.3 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 10381 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 38996 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 6160 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 18398 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
10 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 17110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 27295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 8150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 600 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 150 | 168.3 | 56391 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 31245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 60518 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
8 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 43095 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 57618 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 43245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
10 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 31161 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 27298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
10 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 43111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 29494 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 4770 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 13275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 7543 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 11575 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 10518 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 11913 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 574 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 15717 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1339 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 11829 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 400 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 9498.91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1392 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 25877 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 404 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 19490 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1374 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 500 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 8835 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1589 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 4652 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 852 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 552 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 804 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 14295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 11904 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 8826.91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 35472 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1952 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 752 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 1202 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 290.339 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 970 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 5380 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 4678 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 38960 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 33539 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 718 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 670 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 5080 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 39070 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 33782 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 3049 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 435.047 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 3100.82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 2939 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 844.075 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 125 | 139.7 | 2991.16 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 22133 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 51304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 42008 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 283.442 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 9064.69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 80 | 88.9 | 332.881 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1583.24 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 414.243 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 6992.67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 40 | 48.3 | 1275.73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stahlrohr nach DIN 2448 | EG_Verwaltung_FFB | 32 | 42.4 | 22331 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
