Properties of the parts of a building model (IFC2X3), part 6 of 18

# IfcFlowFitting: T-Stück oben gerade (66)
Name | In | Section No | Geom-Thickness (mm) (mm) | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Side 3 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Branch length (mm) (mm) | Geom-Distance to branch (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Pos. No. | Floor | Floor No. | Building = Building No.
T-Stück oben gerade | EG_Verwaltung_FFB |  | 500 | 450 | 500 | 800 | 1100 | 150 | 150 | 2.72 | L_Zuluft | 17.408
T-Stück oben gerade | EG_Verwaltung_FFB |  | 500 | 300 | 300 | 400 | 700 | 150 | 150 | 1.39 | L_Abluft | 6.672
T-Stück oben gerade | EG_Verwaltung_FFB |  | 500 | 250 | 250 | 350 | 650 | 150 | 150 | 1.23 | L_Zuluft | 5.904
2 x T-Stück oben gerade | EG_Verwaltung_FFB |  | 250 | 300 | 200 | 500 | 800 | 250 | 150 | 1.255 | L_Zuluft | 6.024
T-Stück oben gerade | EG_Verwaltung_FFB |  | 350 | 200 | 250 | 400 | 600 | 100 | 100 | 1 | L_Zuluft | 4.536

# IfcFlowFitting: Übergang asymmetrisch (174)
Description: Übergang asymmetrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Übergang asymmetrisch; Abbreviation: UA
Name | In | Section No | Geom-Section 1 side 1 (mm) (mm) | Geom-Section 1 side 2 (mm) (mm) | Geom-Section 2 side 1 (mm) (mm) | Geom-Section 2 side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Offset 1 (mm) (mm) | Geom-Offset 2 (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Übergang asymmetrisch | Wartung_FFB | 93 | 1300 | 1253 | 900 | 900 | 500 | 124.705 | -200 | 3.53091 | L_Aussenluft | 28.2473 | 1.79382 | 914 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 918 | 1530 | 900 | 900 | 500 | 0 | 0.01 | 3.93786 | L_Fortluft | 31.5029 | 1.25749 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 2 | 900 | 900 | 600 | 700 | 500 | 0 | -150 | 1.93866 | L_Zuluft | 12.4074 | 1.93114 | 355 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 3 | 900 | 900 | 600 | 700 | 500 | 0 | -150 | 1.93866 | L_Abluft | 12.4074 | 0.637546 | 385 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 28 | 675 | 700 | 500 | 500 | 500 | 0.01 | 0 | 1.45679 | L_Aussenluft | 9.32343 | 1.98461 | 296 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 675 | 700 | 500 | 500 | 500 | 0.01 | 0 | 1.45679 | L_Fortluft | 9.32343 | 0.571097 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 30 | 700 | 510 | 500 | 400 | 500 | -0.01 | 0.01 | 1.23894 | L_Fortluft | 7.92919 | 1.58242 | 394 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 700 | 510 | 500 | 400 | 500 | -0.01 | 0.01 | 1.23894 | L_Aussenluft | 7.92919 | 0.494476 | 49 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 17 | 800 | 675 | 600 | 450 | 300 | -75.5 | -100 | 1 | L_Aussenluft | 6.32833 | 1.90407 | 155 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 612 | 918 | 600 | 500 | 500 | -208.897 | -6 | 1.65841 | L_Zuluft | 10.6138 | 2.34003 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 2 | 612 | 918 | 600 | 500 | 500 | -208.897 | -6 | 1.65841 | L_Abluft | 10.6138 | 0.767692 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 800 | 758 | 600 | 500 | 500 | -0.5 | -100 | 1.75247 | L_Fortluft | 11.2158 | 0.64802 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 53 | 800 | 758 | 600 | 500 | 300 | -0.5 | -100 | 1.23193 | L_Aussenluft | 7.88434 | 2.16106 | 607 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 1000 | 1200 | 600 | 1000 | 500 | 0 | -200 | 2.36947 | L_Abluft | 18.9558 | 0.637795 | 128 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 79 | 800 | 600 | 800 | 500 | 500 | 0 | 0 | 1.42773 | L_Zuluft | 9.13744 | -0.282792 | 402 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 81 | 350 | 500 | 350 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.73695 | 0.722732 | 427 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 76 | 800 | 700 | 800 | 600 | 300 | 0 | 0 | 1 | L_Zuluft | 6.07157 | -0.455535 | 356 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 115 | 350 | 400 | 350 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.18979 | -0.444391 | 230 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 114 | 400 | 400 | 400 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.33578 | -0.489941 | 215 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 113 | 400 | 500 | 400 | 400 | 300 | 0 | 0 | 1 | L_Zuluft | 2.73221 | 0.0000103029 | 200 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 108 | 800 | 600 | 800 | 500 | 300 | 0 | 0 | 1 | L_Zuluft | 5.6668 | -0.484187 | 119 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 2448 | 2448 | 1800 | 2000 | 500 | 0 | -324 | 6.57381 | L_Abluft | 57.8495 | 0.612417 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 2448 | 2448 | 1800 | 2000 | 500 | 0 | -324 | 6.57381 | L_Zuluft | 57.8495 | 0.677188 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 106 | 800 | 700 | 800 | 600 | 300 | 0 | 0 | 1 | L_Zuluft | 6.07157 | -0.656741 | 91 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 5 | 1500 | 1400 | 1500 | 700 | 500 | -300 | 0 | 3.71381 | L_Zuluft | 29.7105 | 2.12904 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 110 | 500 | 800 | 500 | 700 | 300 | 0 | 0 | 1 | L_Zuluft | 5.26203 | -1.14071 | 148 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 1253 | 1300 | 900 | 900 | 500 | 0 | -144.361 | 3.26944 | L_Fortluft | 26.1555 | 0.542177 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 46 | 350 | 500 | 350 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.73695 | 0.745494 | 140 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 44 | 800 | 600 | 800 | 500 | 300 | 0 | 0 | 1 | L_Zuluft | 5.6668 | -0.30498 | 115 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 41 | 800 | 700 | 800 | 600 | 300 | 0 | 0 | 1 | L_Zuluft | 6.07157 | -0.471716 | 67 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 8 | 3059 | 1982 | 1500 | 1400 | 750 | -42.3405 | -884.397 | 11.691 | L_Aussenluft | 102.881 | 4.87668 | 126 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 20 | 350 | 350 | 350 | 300 | 300 | 0 | 0 | 1 | L_Zuluft | 2.04381 | -0.349084 | 299 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 2 | 1000 | 1400 | 3460 | 923 | 750 | 62.3405 | 1230 | 12.6285 | L_Fortluft | 111.131 | 0.488132 | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 3 | 1000 | 1400 | 3460 | 923 | 750 | 62.3405 | 1230 | 12.6285 | L_Fortluft | 111.131 | 0.488132 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 19 | 350 | 400 | 350 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.18979 | -0.500768 | 284 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 18 | 400 | 600 | 400 | 350 | 300 | 20 | 0 | 1 | L_Zuluft | 5.16619 | 1.65138 | 273 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 15 | 800 | 700 | 800 | 600 | 300 | 0 | 0 | 1 | L_Zuluft | 6.07157 | -0.442793 | 240 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 39 | 800 | 700 | 800 | 700 | 500 | 150 | 0 | 1.56605 | L_Zuluft | 10.0227 |  | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 500 | 500 | 500 | 500 | 300 | 12.132 | 0 | 1 | L_Zuluft | 2.88235 |  | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 2 | 1400 | 1600 | 1400 | 1000 | 500 | 0 | 0 | 4.68615 | L_Abluft | 37.4892 | 0.934802 | 231 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 1 | 2000 | 1600 | 1800 | 1600 | 500 | 0.00101563 | -100 | 3.67129 | L_Abluft | 29.3704 | -0.468418 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 500 | 300 | 350 | 300 | 500 | 184.983 | -153.761 | 1 | L_Zuluft | 4.09437 | 0.735527 | 582 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 18 | 500 | 300 | 500 | 350 | 500 | 84.9823 | 0 | 1 | L_Zuluft | 4.13851 | 0.116562 | 523 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 35 | 800 | 400 | 800 | 400 | 500 | 4.31217 | 0 | 1.20004 | L_Abluft | 7.68029 |  | 307 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 43 | 300 | 800 | 300 | 550 | 500 | 24.7952 | 124.312 | 1.25518 | L_Abluft | 8.03316 | 0.807454 | 270 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 47 | 300 | 800 | 350 | 300 | 500 | 20.9382 | 274.312 | 1.58854 | L_Abluft | 10.1667 | 2.39629 | 235 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 2 | 1200 | 1800 | 1200 | 1000 | 500 | -50.6923 | 0 | 5.40487 | L_Zuluft | 43.239 | 1.24018 | 503 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 1000 | 700 | 1000 | 500 | 300 | 0 | 0 | 1.22589 | L_Zuluft | 7.84568 | 0.817987 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 1000 | 700 | 1000 | 500 | 300 | 0 | 0 | 1.22589 | L_Zuluft | 7.84568 | 0.35246 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 4 | 1000 | 800 | 1000 | 600 | 300 | 44.7548 | 0 | 1.39383 | L_Zuluft | 8.92052 | 0.5908 | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 4 | 1000 | 800 | 1000 | 600 | 300 | 44.7548 | 0 | 1.39383 | L_Zuluft | 8.92052 | 0.251834 | 58 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 10 | 1000 | 800 | 1000 | 600 | 300 | 44.7548 | 0 | 1.39383 | L_Zuluft | 8.92052 | 0.5908 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 10 | 1000 | 800 | 1000 | 600 | 300 | 44.7548 | 0 | 1.39383 | L_Zuluft | 8.92052 | 0.251834 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 25 | 1500 | 1200 | 1200 | 500 | 500 | 0 | -150 | 4.64526 | L_Abluft | 37.162 | 0.694098 | 65 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 6 | 600 | 1800 | 1200 | 1000 | 750 | 0 | 650 | 5.26361 | L_Abluft | 42.1089 | 0.0752442 | 107 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 6 | 600 | 1800 | 1200 | 1000 | 750 | 0 | -50 | 5.26361 | L_Abluft | 42.1089 | 0.188883 | 109 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 1200 | 500 | 600 | 1000 | 500 | 500 | -300 | 2.40416 | L_Abluft | 19.2333 | -0.0355567 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 1200 | 500 | 600 | 1000 | 500 | 500 | -300 | 2.40416 | L_Abluft | 19.2333 | -0.0355567 | 136 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 41 | 800 | 600 | 800 | 600 | 500 | 150 | 0 | 1.46164 | L_Zuluft | 9.35451 |  | 74 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 25 | 1200 | 500 | 600 | 1000 | 500 | 500 | -450 | 2.40416 | L_Abluft | 19.2333 | -0.0355567 | 70 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB | 7 | 1000 | 700 | 1000 | 500 | 300 | -0.01 | 0 | 1.22589 | L_Zuluft | 7.84568 | 0.35246 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 800 | 1000 | 600 | 300 | 0 | -0.0312908 | 1.298 | L_Zuluft | 8.30719 | 0.5908
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 800 | 1000 | 600 | 300 | 0 | 0.0312908 | 1.298 | L_Zuluft | 8.30719 | 0.251834
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 800 | 1000 | 600 | 300 | 0 | -0.0312908 | 1.298 | L_Zuluft | 8.30719
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 800 | 1000 | 600 | 300 | 0 | 0.0312908 | 1.298 | L_Zuluft | 8.30719
Übergang asymmetrisch | Wartung_FFB |  | 2200 | 1400 | 4060 | 2274 | 750 | 818 | 930 | 15.1349 | L_Fortluft | 133.188 | 3.90479
Übergang asymmetrisch | Wartung_FFB |  | 2200 | 1400 | 4848 | 2174 | 1000 | 1214.1 | 1322.5 | 23.3188 | L_Aussenluft | 205.205 | 5.31154
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 700 | 1000 | 500 | 500 | 0 | 0 | 1.83096 | L_Zuluft | 11.7181 | 0.785261
Übergang asymmetrisch | Wartung_FFB |  | 1200 | 1000 | 1500 | 500 | 500 | 0 | 300 | 3.11127 | L_Zuluft | 24.8902 | 1.28718
Übergang asymmetrisch | Wartung_FFB |  | 1200 | 1000 | 1200 | 500 | 300 | -50.6923 | 0 | 2.37713 | L_Abluft | 19.017 | 2.52678
Übergang asymmetrisch | Wartung_FFB |  | 600 | 500 | 500 | 600 | 300 | 100 | -50 | 1 | L_Abluft | 4.45249 | -1.13837
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 550 | 800 | 500 | 500 | 50 | -100 | 1.5807 | L_Abluft | 10.1165 | 0.569199
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 500 | 700 | 400 | 500 | 50 | -150 | 1.56605 | L_Abluft | 10.0227 | 1.41915
Übergang asymmetrisch | Wartung_FFB |  | 1000 | 550 | 800 | 500 | 500 | 100.001 | -100 | 1.61825 | L_Abluft | 10.3568 | 0.569199
Übergang asymmetrisch | Wartung_FFB |  | 1200 | 1000 | 1000 | 800 | 300 | 0 | -100 | 1.58644 | L_Zuluft | 12.6915 | 0.809172
Übergang asymmetrisch | Wartung_FFB |  | 1300 | 1300 | 1200 | 1000 | 300 | -50 | -50 | 2.03066 | L_Zuluft | 16.2453 | 0.6369
Übergang asymmetrisch | Wartung_FFB |  | 600 | 600 | 500 | 600 | 300 | 0.0267996 | -50 | 1 | L_Zuluft | 4.67156
Übergang asymmetrisch | EG_Verwaltung_FFB | 26 | 300 | 250 | 250 | 200 | 300 | 0 | -25 | 1 | L_Zuluft | 1.60585 | 1.02831 | 688 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 28 | 300 | 250 | 250 | 200 | 300 | 0 | -25 | 1 | L_Abluft | 1.60585 | 0.376717 | 737 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 26 | 300 | 300 | 300 | 250 | 300 | 0 | 0 | 1 | L_Abluft | 1.75184 | 0.11937 | 706 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 24 | 300 | 300 | 300 | 250 | 300 | 0 | 0 | 1 | L_Zuluft | 1.75184 | -0.205093 | 651 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 24 | 400 | 350 | 400 | 300 | 300 | 0 | 0 | 1 | L_Abluft | 2.18979 | 0.0890811 | 652 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 78 | 250 | 400 | 250 | 300 | 300 | 0 | 0 | 1 | L_Zuluft | 1.97326 | 0.280172 | 228 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 69 | 250 | 400 | 250 | 300 | 300 | 0 | 0 | 1 | L_Abluft | 1.97326 | 0.180327 | 355 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 77 | 450 | 300 | 400 | 250 | 300 | 0 | 0 | 1 | L_Zuluft | 2.18979 | 0.405394 | 214 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 68 | 450 | 300 | 400 | 250 | 300 | 0 | -50 | 1 | L_Abluft | 2.18979 | 0.244735 | 340 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 76 | 450 | 400 | 450 | 300 | 300 | 0 | 0 | 1 | L_Zuluft | 2.58042 | 0.330171 | 179 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 67 | 450 | 400 | 450 | 300 | 300 | 0 | 0 | 1 | L_Abluft | 2.58042 | 0.212508 | 305 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 75 | 400 | 500 | 400 | 450 | 300 | 0 | 0 | 1 | L_Zuluft | 2.62775 | -0.520773 | 148 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 66 | 400 | 500 | 400 | 450 | 300 | 0 | 0 | 1 | L_Abluft | 2.62775 | 0.0518967 | 274 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 74 | 400 | 550 | 400 | 500 | 300 | 0 | 0 | 1 | L_Zuluft | 3.69832 | -0.616226 | 117 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 65 | 400 | 550 | 400 | 500 | 300 | 0 | 0 | 1 | L_Abluft | 3.69832 | 0.0501054 | 243 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 73 | 550 | 500 | 550 | 400 | 300 | 0 | 0 | 1 | L_Zuluft | 4.2501 | 0.00000910098 | 87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 64 | 550 | 500 | 550 | 400 | 300 | 0 | 0 | 1 | L_Abluft | 4.2501 | 0.164182 | 212 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 61 | 350 | 500 | 350 | 200 | 300 | 0 | 0 | 1 | L_Zuluft | 3.46199 | 2.2418 | 260 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 84 | 350 | 500 | 350 | 200 | 300 | 0 | 0 | 1 | L_Abluft | 3.46199 | 0.490573 | 63 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 56 | 350 | 250 | 350 | 200 | 300 | 0 | 0 | 1 | L_Zuluft | 1.75184 | 0.000419715 | 387 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 22 | 300 | 400 | 400 | 400 | 300 | 0.01 | -0.01 | 1 | L_Zuluft | 2.42863 | 0.342916 | 603 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 20 | 200 | 250 | 200 | 300 | 300 | -0.01 | 0.01 | 1 | L_Abluft | 1.45986 | 0.0921855 | 505 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 19 | 300 | 250 | 300 | 200 | 300 | 0 | 0 | 1 | L_Abluft | 1.60585 | 0.151411 | 486 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 10 | 200 | 250 | 200 | 300 | 300 | 0 | 0.01 | 1 | L_Zuluft | 1.45986 | -0.158387 | 507 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 16 | 500 | 200 | 500 | 250 | 300 | 0 | 0.01 | 1 | L_Abluft | 2.18979 | 0.27834 | 413 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 7 | 500 | 200 | 500 | 250 | 300 | 0 | 0.01 | 1 | L_Zuluft | 2.18979 | 0.000822641 | 411 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 600 | 300 | 600 | 400 | 300 | 100 | 0 | 1 | L_Abluft | 4.04772 | 0.200191 | 81 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 4 | 600 | 450 | 600 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 4.2501 | 0.141031 | 36 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 5 | 600 | 350 | 600 | 300 | 300 | 0 | 0 | 1 | L_Zuluft | 3.69832 | -0.293328 | 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 300 | 600 | 300 | 500 | 300 | 0 | 0.01 | 1 | L_Zuluft | 3.64294 | -0.171979 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 7 | 300 | 500 | 300 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.57595 | 0.669544 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 7 | 300 | 600 | 300 | 350 | 297 | 0 | 0 | 1 | L_Abluft | 4.47221 | 0.461925 | 111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 8 | 350 | 300 | 300 | 250 | 300 | 0 | -50 | 1 | L_Abluft | 1.89782 | 0.231588 | 127 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 5 | 300 | 400 | 300 | 350 | 300 | 0 | 0 | 1 | L_Zuluft | 2.04381 | 0.0590652 | 228 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 4 | 300 | 400 | 300 | 350 | 300 | 0 | 0 | 1 | L_Abluft | 2.04381 | -0.369453 | 191 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 22 | 200 | 300 | 200 | 200 | 300 | 0 | 0 | 1 | L_Zuluft | 1.51789 | 0.344611 | 123 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 600 | 400 | 350 | 200 | 350 | 0 | -125 | 1 | L_Abluft | 5.15984 | 0.644105 | 569 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 19 | 200 | 200 | 350 | 300 | 300 | 100 | 75 | 1 | L_Abluft | 1.97326 | 0.552914 | 166 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 18 | 400 | 500 | 400 | 450 | 300 | 0 | 0 | 1 | L_Zuluft | 2.62775 | -0.606637 | 449 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 20 | 400 | 500 | 400 | 450 | 300 | 0 | 0 | 1 | L_Abluft | 2.62775 | 0.0575286 | 489 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 5 | 700 | 450 | 600 | 250 | 500 | 150.003 | -50 | 1.40376 | L_Abluft | 8.98405 | 0.582732 | 806 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 54 | 700 | 200 | 500 | 200 | 500 | 175 | -100 | 1 | L_Zuluft | 6.10261 | 0.63826 | 382 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 54 | 500 | 200 | 400 | 250 | 500 | 175 | -50 | 1 | L_Zuluft | 3.55986 | -1.00414 | 384 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 5 | 200 | 300 | 200 | 200 | 300 | 0 | 0 | 1 | L_Abluft | 1.51789 | 0.337821 | 273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 8 | 300 | 300 | 300 | 200 | 300 | 0 | 0 | 1 | L_Abluft | 1.82147 | 0.423763 | 201 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 4 | 600 | 450 | 600 | 400 | 300 | 0 | 0 | 1 | L_Abluft | 4.08762 | 0.062047 | 56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 19 | 450 | 700 | 400 | 500 | 500 | -75 | -50 | 1.18539 | L_Abluft | 7.58651 | 0.408518 | 449 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 19 | 500 | 400 | 500 | 400 | 500 | 25 | 0 | 1 | L_Abluft | 4.3254 |  | 452 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 450 | 350 | 350 | 250 | 600 | 250.003 | -100 | 1.1114 | L_Zuluft | 5.33471 | 1.01714 | 789 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 600 | 250 | 400 | 300 | 600 | 400 | -100 | 1.22589 | L_Abluft | 7.84568 | 0.143647 | 822 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 55 | 800 | 300 | 650 | 300 | 300 | 50 | -75 | 1 | L_Abluft | 4.354 | 0.388453 | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 14 | 500 | 300 | 550 | 250 | 300 | 0 | 25 | 1 | L_Zuluft | 3.11437 | -0.762206 | 25 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 17 | 300 | 200 | 350 | 250 | 300 | 50 | 25 | 1 | L_Zuluft | 1.75184 | 0.738083 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 7 | 400 | 300 | 250 | 200 | 300 | -49.9971 | -75 | 1 | L_Abluft | 2.07805 | 0.577947 | 843 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 17 | 400 | 500 | 300 | 600 | 300 | 100 | -50 | 1 | L_Zuluft | 3.64294 | 0.0665203 | 433 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 4 | 600 | 450 | 650 | 350 | 300 | 0 | 25 | 1 | L_Zuluft | 4.2501 | -0.310392 | 200 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 300 | 300 | 300 | 200 | 300 | -30.0071 | 0 | 1 | L_Zuluft | 1.77441 | 0.337821 | 293 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 6 | 300 | 200 | 300 | 200 | 302.854 | 100.075 | 0 | 1 | L_Zuluft | 1.53101 |  | 319 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB | 5 | 300 | 200 | 300 | 200 | 300 | 100 | 0 | 1 | L_Abluft | 1.51789 |  | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 400 | 300 | 400 | 250 | 300 | 0 | 0 | 1 | L_Abluft | 2.04381 | -0.117707
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 650 | 350 | 650 | 300 | 300 | 0 | 0 | 1 | L_Abluft | 3.89297 | -0.376453
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 400 | 300 | 400 | 358.062 | 73.4342 | 0 | 1 | L_Abluft | 2.6317 | -0.211376
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 450 | 350 | 500 | 450 | 300 | 150 | 25 | 1 | L_Zuluft | 3.05894 | 0.841489
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 450 | 500 | 450 | 350 | 300 | 25 | 0 | 1 | L_Zuluft | 3.16748 | 0.799027
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 550 | 250 | 500 | 300 | 300 | 126.03 | -25 | 1 | L_Abluft | 3.33207 | -0.642843
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 250 | 350 | 200 | 250 | 300 | 0 | -25 | 1 | L_Zuluft | 1.82147
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 300 | 500 | 250 | 500 | 500 | 232.474 | 0 | 1 | L_Zuluft | 4.23477
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 300 | 500 | 250 | 500 | 500 | 232.474 | 0 | 1 | L_Abluft | 4.23477
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 500 | 300 | 500 | 500 | 232.474 | -50 | 1 | L_Zuluft | 4.49944
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 500 | 300 | 500 | 400 | 232.454 | -50 | 1 | L_Abluft | 3.77514
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 650 | 350 | 500 | 300 | 112.5 | -180 | 1 | L_Zuluft | 5.10247
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 500 | 350 | 500 | 350 | 300 | 180 | -108.89 | 1 | L_Abluft | 2.85483
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 600 | 300 | 600 | 300 | 300 | 75 | 0 | 1 | L_Zuluft | 3.56236
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 600 | 300 | 600 | 450 | 500 | 150 | 0 | 1.09623 | L_Zuluft | 7.01589
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 300 | 200 | 200 | 200 | 300 | 73.7538 | -50 | 1 | L_Abluft | 1.48288
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 450 | 450 | 350 | 450 | 500 | 250 | 0 | 1.00623 | L_Zuluft | 4.82991
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 600 | 450 | 600 | 450 | 347.395 | 136.575 | 0 | 1 | L_Zuluft | 5.01685
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 600 | 450 | 600 | 450 | 349.605 | 136.575 | 0 | 1 | L_Zuluft | 5.0445
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 600 | 400 | 600 | 400 | 347.395 | 136.575 | 0 | 1 | L_Abluft | 4.77795
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 250 | 200 | 200 | 200 | 300 | 50 | -25 | 1 | L_Abluft | 1.31388
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 300 | 250 | 300 | 200 | 300 | 19.9756 | 0 | 1 | L_Zuluft | 1.62652
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 200 | 400 | 200 | 400 | 173.97 | 50 | 0 | 1 | L_Abluft | 1.04263
2 x Übergang asymmetrisch | EG_Verwaltung_FFB |  | 400 | 200 | 400 | 200 | 500 | 100 | 0 | 1 | L_Abluft | 2.93704
2 x Übergang asymmetrisch | EG_Verwaltung_FFB |  | 400 | 200 | 400 | 200 | 500 | 100 | 0 | 1 | L_Zuluft | 2.93704
2 x Übergang asymmetrisch | EG_Verwaltung_FFB |  | 400 | 300 | 400 | 200 | 295.192 | 0 | 0 | 1 | L_Abluft | 2.09442
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 550 | 250 | 500 | 300 | 300 | 176.03 | -25 | 1 | L_Abluft | 3.56179
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 400 | 500 | 350 | 450 | 300 | 0 | 0 | 1 | L_Zuluft | 2.62775
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 450 | 350 | 350 | 300 | 300.004 | 0 | -50 | 1 | L_Zuluft | 2.33581
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 550 | 400 | 550 | 300 | 300 | 0 | 0 | 1 | L_Abluft | 3.84533
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 400 | 600 | 350 | 500 | 500 | 108.895 | -80 | 1.08377 | L_Abluft | 6.9361
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 650 | 350 | 650 | 250 | 112.5 | 80 | 1 | L_Zuluft | 3.50907
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 200 | 350 | 200 | 400 | 266.14 | 0 | 1 | L_Zuluft | 2.53677
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 450 | 400 | 400 | 350 | 300 | 70 | -50 | 1 | L_Abluft | 2.63658
Übergang asymmetrisch | EG_Verwaltung_FFB |  | 450 | 400 | 400 | 400 | 300 | 120 | 0 | 1 | L_Zuluft | 2.63658

# IfcFlowFitting: Übergang symmetrisch (89)
Description: Übergang symmetrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Übergang symmetrisch; Abbreviation: US
Name | In | Section No | Geom-Section 1 side 1 (mm) (mm) | Geom-Section 1 side 2 (mm) (mm) | Geom-Section 2 side 1 (mm) (mm) | Geom-Section 2 side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Offset 1 (mm) (mm) | Geom-Offset 2 (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Übergang symmetrisch | Wartung_FFB | 93 | 918 | 1530 | 900 | 900 | 500 | -315 | -9 | 2.8933 | L_Aussenluft | 23.1464 | 0.470544 | 882 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 918 | 1530 | 900 | 900 | 500 | -315 | -9 | 2.8933 | L_Zuluft | 23.1464 | 1.24028 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 2 | 1530 | 918 | 900 | 900 | 500 | 0.01 | 0.01 | 2.8933 | L_Abluft | 23.1464 | 0.470544 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 918 | 500 | 500 | 500 | 0.01 | 0.01 | 1.65829 | L_Zuluft | 10.613 | 2.45174 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 2 | 918 | 612 | 500 | 500 | 500 | 0.01 | 0.01 | 1.65829 | L_Abluft | 10.613 | 0.624939 | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 28 | 918 | 500 | 500 | 500 | 500 | 0 | -209 | 1.53689 | L_Aussenluft | 9.83613 | 0.5557 | 265 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 918 | 500 | 500 | 500 | 0.01 | 0.01 | 1.65829 | L_Fortluft | 10.613 | 2.45174 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 30 | 612 | 612 | 400 | 500 | 300 | 0.01 | 0.01 | 1 | L_Fortluft | 4.98493 | 0.520246 | 365 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 612 | 500 | 400 | 300 | -106 | -56 | 1 | L_Aussenluft | 4.98493 | 1.54529 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 2 | 612 | 612 | 500 | 400 | 300 | 0.01 | 0.01 | 1 | L_Zuluft | 4.98493 | 0.520246 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 612 | 500 | 400 | 300 | 0.01 | 0.01 | 1 | L_Abluft | 4.98493 | 1.61946 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 17 | 612 | 918 | 450 | 600 | 500 | 0.01 | 0.01 | 1.6055 | L_Aussenluft | 10.2752 | 0.592714 | 127 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 918 | 600 | 450 | 500 | 0.01 | 0.01 | 1.68926 | L_Fortluft | 10.8113 | 2.06729 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 675 | 800 | 450 | 600 | 500 | 0.01 | 0.01 | 1.51188 | L_Fortluft | 9.676 | 0.580382 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 918 | 600 | 450 | 500 | -234 | -6 | 1.68926 | L_Zuluft | 10.8113 | 2.06729 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 2 | 612 | 918 | 600 | 450 | 500 | -234 | -6 | 1.68926 | L_Abluft | 10.8113 | 0.592714 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 53 | 612 | 918 | 500 | 600 | 500 | 0.01 | 0.01 | 1.6055 | L_Aussenluft | 10.2752 | 0.613168 | 572 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 612 | 918 | 600 | 500 | 500 | 0.01 | 0.01 | 1.65829 | L_Fortluft | 10.613 | 1.8213 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 25 | 1400 | 500 | 1400 | 600 | 300 | 0.01 | 0.01 | 1.21655 | L_Abluft | 9.73242 | 0.094011 | 82 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 7 | 1400 | 500 | 1400 | 600 | 300 | 0.01 | 0.01 | 1.21655 | L_Abluft | 9.73242 | 0.094011 | 142 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 6 | 1200 | 1500 | 1200 | 1000 | 500 | 0.01 | 0.01 | 3.01869 | L_Abluft | 24.1495 | 0.403824 | 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 82 | 350 | 350 | 300 | 350 | 300 | 0 | -25 | 1 | L_Zuluft | 2.02299 | -0.300996 | 443 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 83 | 350 | 300 | 300 | 250 | 300 | -25 | -25 | 1 | L_Zuluft | 1.87849 | 0.598612 | 456 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 117 | 350 | 300 | 300 | 250 | 300 | -25 | -25 | 1 | L_Zuluft | 1.87849 | 0.598612 | 263 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 116 | 350 | 350 | 300 | 350 | 300 | 0 | -25 | 1 | L_Zuluft | 2.02299 | -0.300996 | 248 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 2 | 1400 | 1500 | 800 | 1500 | 500 | 0 | -300 | 3.38195 | L_Zuluft | 27.0556 | 1.53031 | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 2142 | 2448 | 1500 | 1400 | 500 | 0.01 | 0.01 | 6.64886 | L_Zuluft | 58.5099 | 3.62424 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 8 | 2142 | 2448 | 1500 | 1400 | 500 | 0.01 | 0.01 | 6.64886 | L_Aussenluft | 58.5099 | 0.882784 | 78 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 2142 | 2448 | 1500 | 1400 | 500 | -524 | -321 | 6.64886 | L_Fortluft | 58.5099 | 4.02747 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 1 | 1500 | 1400 | 2000 | 1400 | 750 | 0 | 250 | 5.37587 | L_Fortluft | 43.007 | 0.322955 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 48 | 350 | 300 | 300 | 250 | 300 | -25 | -25 | 1 | L_Zuluft | 1.87849 | 0.598612 | 168 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 47 | 350 | 350 | 300 | 350 | 300 | 0 | -25 | 1 | L_Zuluft | 2.02299 | -0.300996 | 156 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 21 | 350 | 300 | 300 | 250 | 300 | -25 | -25 | 1 | L_Zuluft | 1.87849 | 0.727702 | 314 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 38 | 800 | 800 | 700 | 800 | 300 | 0 | -50 | 1 | L_Zuluft | 6.22875 | -0.573966 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 11 | 800 | 800 | 700 | 800 | 300 | 0 | -50 | 1 | L_Zuluft | 6.22875 | -0.580987 | 196 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 193 | 2448 | 1400 | 2200 | 1400 | 500 | 0 | -124 | 3.96457 | L_Aussenluft | 34.8882 | 0.0737477 | 656 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 81 | 2448 | 1400 | 2200 | 1400 | 500 | 0 | -124 | 3.96457 | L_Fortluft | 34.8882 | 0.0614542 | 531 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB | 33 | 1800 | 1400 | 1300 | 1400 | 500 | 0 | -250 | 3.57771 | L_Zuluft | 28.6217 | 0.491847 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | Wartung_FFB |  | 400 | 800 | 450 | 800 | 300 | 0 | 25 | 1 | L_Zuluft | 4.81664 | 0.0937148
Übergang symmetrisch | Wartung_FFB |  | 1000 | 450 | 800 | 450 | 300 | 0 | -100 | 1 | L_Zuluft | 5.86919 | 0.438378
Übergang symmetrisch | Wartung_FFB |  | 500 | 300 | 350 | 300 | 300 | 0 | -75 | 1 | L_Abluft | 2.37491 | 0.700323
Übergang symmetrisch | Wartung_FFB |  | 500 | 350 | 400 | 350 | 300 | 0 | -50 | 1 | L_Zuluft | 2.48177
Übergang symmetrisch | EG_Verwaltung_FFB | 27 | 250 | 200 | 200 | 200 | 300 | 0 | -25 | 1 | L_Zuluft | 1.30049 | 0.000383159 | 705 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 23 | 300 | 400 | 300 | 300 | 300 | -50 | 0 | 1 | L_Zuluft | 2.04381 | 0.376352 | 630 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 25 | 300 | 300 | 300 | 400 | 300 | 50 | 0 | 1 | L_Abluft | 2.04381 | 0.242232 | 685 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 16 | 300 | 200 | 250 | 200 | 300 | 0 | -25 | 1 | L_Zuluft | 1.44499 | -0.152972 | 435 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 7 | 200 | 300 | 200 | 250 | 300 | -25 | 0 | 1 | L_Zuluft | 1.44499 | 0.108765 | 355 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 6 | 200 | 300 | 200 | 250 | 300 | -25 | 0 | 1 | L_Abluft | 1.44499 | -0.186872 | 337 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 24 | 200 | 300 | 200 | 200 | 300 | 0.01 | 0.01 | 1 | L_Abluft | 1.45986 | 0.995602 | 68 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 9 | 200 | 200 | 200 | 300 | 300 | 50 | 0 | 1 | L_Zuluft | 1.45986 | 0.937336 | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 9 | 300 | 200 | 250 | 200 | 300 | 0.01 | 0.01 | 1 | L_Abluft | 1.44499 | 0.0953918 | 224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 17 | 300 | 500 | 300 | 350 | 300 | 0.01 | 0.01 | 1 | L_Abluft | 2.37491 | 0.248409 | 125 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 18 | 200 | 300 | 200 | 200 | 300 | 0.01 | 0.01 | 1 | L_Zuluft | 1.45986 | 0.937336 | 121 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 7 | 250 | 350 | 200 | 250 | 300 | -50 | -25 | 1 | L_Zuluft | 1.75184 | 1.17766 | 800 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 16 | 400 | 200 | 200 | 200 | 300 | 0 | -100 | 1 | L_Abluft | 1.82147 | 1.30065 | 474 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 7 | 400 | 200 | 200 | 200 | 300 | 0 | -100 | 1 | L_Abluft | 1.82147 | 1.30669 | 519 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 9 | 400 | 200 | 200 | 200 | 300 | 0 | -100 | 1 | L_Abluft | 1.82147 | 1.86425 | 510 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 75 | 300 | 400 | 250 | 400 | 300 | 0 | -25 | 1 | L_Abluft | 2.02299 | -0.214521 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 66 | 700 | 300 | 500 | 300 | 300 | 0 | -100 | 1 | L_Abluft | 4.04772 | 0.562175 | 148 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 63 | 700 | 300 | 500 | 300 | 300 | 0 | -100 | 1 | L_Abluft | 4.04772 | 0.562175 | 162 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 59 | 300 | 400 | 250 | 400 | 300 | 0 | -25 | 1 | L_Abluft | 2.02299 | -0.214521 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 58 | 800 | 300 | 650 | 300 | 300 | 0 | -75 | 1 | L_Abluft | 4.354 | 0.388453 | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 56 | 300 | 400 | 250 | 400 | 300 | 0 | -25 | 1 | L_Abluft | 2.02299 | -0.214521 | 223 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 46 | 550 | 200 | 400 | 200 | 300 | 0 | -75 | 1 | L_Abluft | 2.96864 | 0.683694 | 291 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 45 | 550 | 200 | 400 | 200 | 300 | 0 | -75 | 1 | L_Abluft | 2.96864 | 0.683694 | 299 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 3 | 500 | 250 | 400 | 250 | 300 | 0 | -50 | 1 | L_Zuluft | 2.18979 | 0.00000915057 | 147 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 4 | 250 | 200 | 200 | 200 | 300 | 0 | -25 | 1 | L_Zuluft | 1.30049 | 0.000424553 | 217 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 16 | 250 | 350 | 250 | 550 | 300 | 100 | 0 | 1 | L_Zuluft | 3.23817 | 1.16538 | 75 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 12 | 300 | 300 | 200 | 200 | 300 | -50 | -50 | 1 | L_Zuluft | 1.75184 | 0.474496 | 243 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 25 | 350 | 200 | 300 | 200 | 300 | 0.01 | 0.01 | 1 | L_Zuluft | 1.58949 | -0.315049 | 221 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB | 36 | 300 | 200 | 200 | 200 | 300 | 0 | -50 | 1 | L_Abluft | 1.45986 | 0.408764 | 220 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Übergang symmetrisch | EG_Verwaltung_FFB |  | 500 | 450 | 400 | 450 | 267.138 | 0 | -50 | 1 | L_Zuluft | 2.47861
3 x Übergang symmetrisch | EG_Verwaltung_FFB |  | 350 | 450 | 300 | 350 | 300 | -50 | -25 | 1 | L_Zuluft | 2.33578 | 1.17808
Übergang symmetrisch | EG_Verwaltung_FFB |  | 400 | 550 | 300 | 550 | 300 | 0 | -50 | 1 | L_Abluft | 3.69832 | 0.387174
Übergang symmetrisch | EG_Verwaltung_FFB |  | 300 | 350 | 450 | 450 | 300 | 50 | 75 | 1 | L_Zuluft | 2.67177 | 1.95003
Übergang symmetrisch | EG_Verwaltung_FFB |  | 350 | 450 | 450 | 500 | 300 | 25 | 50 | 1 | L_Zuluft | 2.77374 | 0.841489
Übergang symmetrisch | EG_Verwaltung_FFB |  | 450 | 450 | 300 | 350 | 300 | -50 | -75 | 1 | L_Zuluft | 2.67177 | 1.95003
Übergang symmetrisch | EG_Verwaltung_FFB |  | 450 | 500 | 350 | 450 | 300 | -25 | -50 | 1 | L_Zuluft | 2.77374 | 0.841489
2 x Übergang symmetrisch | EG_Verwaltung_FFB |  | 300 | 350 | 350 | 450 | 300 | 50 | 25 | 1 | L_Zuluft | 2.33578 | 1.17808
Übergang symmetrisch | EG_Verwaltung_FFB |  | 500 | 500 | 450 | 500 | 300 | 0 | -25 | 1 | L_Zuluft | 2.88998 | -0.537981
2 x Übergang symmetrisch | EG_Verwaltung_FFB |  | 500 | 300 | 350 | 300 | 300 | 0 | -75 | 1 | L_Abluft | 2.37491 | 0.700323
3 x Übergang symmetrisch | EG_Verwaltung_FFB |  | 250 | 300 | 300 | 350 | 300 | 25 | 25 | 1 | L_Abluft | 1.87849 | 0.51006
Übergang symmetrisch | EG_Verwaltung_FFB |  | 350 | 200 | 300 | 200 | 350 | 0 | -25 | 1 | L_Abluft | 1.85271

# IfcFlowMovingDevice: Büro + Aufenthaltsräume (ca. 10.700 m³/h) (2)
In: Wartung_FFB
Description: Büro + Aufenthaltsräume (ca. 10.700 m³/h)
Pset_MEP - Geom-Width (mm): 1607 mm; Name: Büro + Aufenthaltsräume (ca. 10.700 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Name | Geom-Length (mm) (mm) | Geom-Height (mm) (mm)
Büro + Aufenthaltsräume (ca. 10.700 m³/h) | 5509 | 1114
Büro + Aufenthaltsräume (ca. 10.700 m³/h) | 8646 | 1256 | Pset_MEP - Info: ZUL+ABL: 1,6 x 9 x 2,2 m; Info 1: 3500 kg

# IfcFlowMovingDevice: Dachventilator Abluft Notentl. Kälte
In: Wartung_FFB
Description: Dachventilator Abluft Notentl. Kälte
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Network name: Abluft Notentl. Kälte; Geom-Side 1 connection (mm): 590 mm; Geom-Side 2 connection (mm): 590 mm; Tech-Medium: L_Zuluft; Name: Dachventilator Abluft Notentl. Kälte; Info: ca. 5.000 m³/h; Info 1: 100 kg (mit Schalldämmhaube); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowMovingDevice: Dachventilator Abluft Wagenwäsche
In: Wartung_FFB
Description: Dachventilator Abluft Wagenwäsche
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Network name: Abluft Wagenwäsche; Geom-Side 1 connection (mm): 590 mm; Geom-Side 2 connection (mm): 590 mm; Tech-Medium: L_Zuluft; Name: Dachventilator Abluft Wagenwäsche; Info: ca. 4.000 m³/h; Info 1: 100 kg (mit Schalldämmhaube); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowMovingDevice: Dachventilator Rund (2)
In: Wartung_FFB
Description: Dachventilator Rund
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Connection diameter (mm): 450 mm; Tech-Medium: L_Abluft; Name: Dachventilator Rund; Pos. No.: 1; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Network name | Calc-Volumetric flow (m3/h) (m3/hour) | Calc-Total Pressure loss (Pa) (Pa) | Energy demand (W) (W)
Dachventilator Rund | Abluft Wagenwäsche Ber. | 4000 | 289.092 | 382.396
Dachventilator Rund | Abluft Notentl. Kälte Ber. | 5000 | 212.889 | 351.999

# IfcFlowMovingDevice: Druckkasten Verteilkammer (8)
In: EG_Verwaltung_FFB
Description: Druckkasten Verteilkammer
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1250 mm; Name: Druckkasten Verteilkammer; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Width (mm) (mm) | Geom-Height (mm) (mm)
Druckkasten Verteilkammer | 1250 | 515
4 x Druckkasten Verteilkammer | 950 | 635
3 x Druckkasten Verteilkammer | 1445 | 515

# IfcFlowMovingDevice: Halle (ca. 32.600 m³/h) (3)
In: Wartung_FFB
Description: Halle (ca. 32.600 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Halle (ca. 32.600 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Geom-Width (mm) (mm) | Geom-Height (mm) (mm)
Halle (ca. 32.600 m³/h) | 7880 | 2219 | 3010
Halle (ca. 32.600 m³/h) | 11628 | 2219 | 3010 | Pset_MEP - Info: ZUL+ABL: 4,5 x 12 x 3 m; Info 1: 10000 kg
Halle (ca. 32.600 m³/h) | 1760 | 4458 | 306

# IfcFlowMovingDevice: Kaltarbeitsplätze (ca. 3.500 m³/h) (2)
In: Wartung_FFB
Description: Kaltarbeitsplätze (ca. 3.500 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Width (mm): 995 mm; Name: Kaltarbeitsplätze (ca. 3.500 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Geom-Height (mm) (mm)
Kaltarbeitsplätze (ca. 3.500 m³/h) | 7727 | 950 | Pset_MEP - Info: ZUL+ABL: 1 x 8 x 1,6 m; Info 1: 2000 kg
Kaltarbeitsplätze (ca. 3.500 m³/h) | 4897 | 808

# IfcFlowMovingDevice: Kanalventilator (14)
In: Wartung_FFB
Description: Kanalventilator
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Kanalventilator; Pos. No.: 1; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Network name | Geom-Side 1 connection (mm) (mm) | Geom-Side 2 connection (mm) (mm) | Tech-Medium | Calc-Volumetric flow (m3/h) (m3/hour) | Calc-Total Pressure loss (Pa) (Pa) | Energy demand (W) (W)
Kanalventilator | 93 | ZU/AU - Büro+Aufenthaltsräume | 1530 | 918 | L_Zuluft | 10190 | 347.541 | 1171.11
Kanalventilator | 2 | AB/FO - Büro+Aufenthaltsräume | 1530 | 918 | L_Fortluft | 10190 | 327.237 | 1102.69
Kanalventilator | 28 | ZU/AU - Kaltarbeitsplätze | 918 | 612 | L_Zuluft | 3300 | 272.869 | 297.774
Kanalventilator | 2 | AB/FO - Kaltarbeitsplätze | 918 | 612 | L_Fortluft | 3300 | 270.158 | 294.816
Kanalventilator | 2 | ZU/AU - Warmarbeitsplätze | 612 | 612 | L_Zuluft | 2530 | 312.543 | 261.486
Kanalventilator | 30 | AB/FO - Warmarbeitsplätze | 612 | 612 | L_Abluft | 2590 | 311.029 | 266.391
Kanalventilator | 17 | ZU/AU - Lager/Werkstatt | 918 | 612 | L_Zuluft | 3520 | 253.282 | 294.825
Kanalventilator | 2 | AB/FO - Lager/Werkstatt | 918 | 612 | L_Fortluft | 3520 | 233.612 | 271.929
Kanalventilator | 53 | ZU/AU - Technik | 918 | 612 | L_Zuluft | 4670 | 420.821 | 649.879
Kanalventilator | 2 | AB/FO - Technik | 918 | 612 | L_Fortluft | 4610 | 398.368 | 607.3
Kanalventilator | 193 | ZU/AU - Spülküche | 2448 | 2448 | L_Zuluft | 45900 | 236.147 | 3584.37
Kanalventilator | 81 | AB/FO - Spülküche | 2448 | 2448 | L_Abluft | 41900 | 243.704 | 3376.72
Kanalventilator | 8 | ZU/AU - Halle | 2142 | 2448 | L_Zuluft | 32600 | 506.893 | 5464.53
Kanalventilator | 4 | AB/FO - Halle | 2142 | 2448 | L_Abluft | 32800 | 122.202 | 1325.47

# IfcFlowMovingDevice: Lager (ca. 3.700 m³/h) (2)
In: Wartung_FFB
Description: Lager (ca. 3.700 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Width (mm): 995 mm; Name: Lager (ca. 3.700 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Geom-Height (mm) (mm)
Lager (ca. 3.700 m³/h) | 4897 | 808
Lager (ca. 3.700 m³/h) | 7421 | 950 | Pset_MEP - Info: ZUL+ABL: 1 x 7,5 x 1,6 m; Info 1: 2000 kg

# IfcFlowMovingDevice: RohrventilatorRadial
In: EG_Verwaltung_FFB
Description: RohrventilatorRadial
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 2; Network name: Abluft Nassmüllanlage; Geom-Connection diameter (mm): 200 mm; Tech-Medium: L_Abluft; Calc-Volumetric flow (m3/h): 530 m3/hour; Calc-Total Pressure loss (Pa): 89.432 Pa; Energy demand (W): 15.6743 W; Name: RohrventilatorRadial; Pos. No.: 1; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowMovingDevice: Spülküche (ca. 48.000 m³/h)
In: Wartung_FFB
Description: Spülküche (ca. 48.000 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 14154 mm; Geom-Width (mm): 2525 mm; Geom-Height (mm): 2704 mm; Name: Spülküche (ca. 48.000 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowMovingDevice: Spülküche (ca. 48.200 m³/h)
In: Wartung_FFB
Description: Spülküche (ca. 48.200 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 10710 mm; Geom-Width (mm): 2525 mm; Geom-Height (mm): 2704 mm; Name: Spülküche (ca. 48.200 m³/h); Info: ZUL+ABL: 5 x 14 x 3 m; Info 1: 13000 kg; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowMovingDevice: Technik (ca. 4.300 m³/h) (2)
In: Wartung_FFB
Description: Technik (ca. 4.300 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Width (mm): 995 mm; Name: Technik (ca. 4.300 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Geom-Height (mm) (mm)
