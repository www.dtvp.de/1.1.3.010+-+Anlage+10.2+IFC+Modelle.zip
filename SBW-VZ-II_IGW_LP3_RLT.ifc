Properties of the parts of a building model (IFC2X3), part 4 of 18

# IfcFlowFitting: Bogen symmetrisch (442)
Name | In | Section No | Geom-Thickness (mm) (mm) | Geom-Side 1 (mm) (mm) = Geom-Side 2 (mm) (mm) | Geom-Radius (mm) (mm) | Geom-Angle (°) (rad) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Bogen symmetrisch | Wartung_FFB | 111 | 700 | 500 | 100 | 45 | 1.37097 | L_Zuluft | 8.77423 | 9.44715 | 170 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1800 | 2000 | 100 | 90 | 25.8299 | L_Zuluft | 206.639 | 4.33556 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1800 | 2000 | 100 | 90 | 25.8299 | L_Zuluft | 206.639 | 4.33556 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1800 | 2000 | 100 | 90 | 25.8299 | L_Abluft | 206.639 | 3.92088 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2000 | 1800 | 100 | 90 | 23.4423 | L_Abluft | 187.538 | 4.56925 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1800 | 2000 | 100 | 90 | 25.8299 | L_Abluft | 206.639 | 3.92088 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2000 | 1800 | 100 | 30 | 8.44237 | L_Abluft | 67.5389 | 2.27614 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2000 | 1800 | 100 | 90 | 23.4423 | L_Zuluft | 187.538 | 5.0525 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2000 | 1800 | 100 | 30 | 8.32077 | L_Zuluft | 66.5661 | 2.51687 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2000 | 1800 | 100 | 30 | 8.32077 | L_Zuluft | 66.5661 | 2.51687 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 72 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 8.04755 | 88 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 72 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 8.04755 | 86 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 72 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 8.04755 | 81 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 5 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 6.17473 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 5 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 6.17473 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 5 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 6.17473 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1500 | 1400 | 100 | 90 | 14.2459 | L_Zuluft | 113.967 | 10.5564 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1500 | 1400 | 100 | 90 | 14.2459 | L_Zuluft | 113.967 | 10.5564 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 1400 | 100 | 90 | 14.2459 | L_Aussenluft | 113.967 | 11.7309 | 79 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 1400 | 100 | 90 | 14.2459 | L_Aussenluft | 113.967 | 11.7309 | 82 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1400 | 1500 | 100 | 90 | 15.157 | L_Aussenluft | 121.256 | 10.5261 | 92 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1400 | 1500 | 100 | 90 | 15.157 | L_Aussenluft | 121.256 | 10.5261 | 111 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 110 | 700 | 500 | 100 | 45 | 1.37097 | L_Zuluft | 8.77423 | 10.3581 | 151 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 110 | 700 | 500 | 100 | 45 | 1.37097 | L_Zuluft | 8.77423 | 10.3581 | 154 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 111 | 700 | 500 | 100 | 45 | 1.37097 | L_Zuluft | 8.77423 | 9.44715 | 167 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 600 | 500 | 100 | 45 | 1.25673 | L_Aussenluft | 8.04304 | 4.20099 | 591 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 500 | 100 | 90 | 2.29345 | L_Fortluft | 14.6781 | 6.41954 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 600 | 100 | 90 | 2.63903 | L_Fortluft | 16.8898 | 5.16159 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 500 | 100 | 90 | 2.29345 | L_Fortluft | 14.6781 | 6.41954 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 500 | 100 | 30 | 1 | L_Fortluft | 5.83136 | 3.36903 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 500 | 100 | 30 | 1 | L_Fortluft | 5.83136 | 3.36903 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1500 | 1400 | 100 | 90 | 14.2459 | L_Fortluft | 113.967 | 11.7309 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1500 | 1400 | 100 | 90 | 14.2459 | L_Fortluft | 113.967 | 11.7309 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 1400 | 1000 | 100 | 45 | 4.6269 | L_Fortluft | 37.0152 | 4.51244 | 42 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 1400 | 1000 | 100 | 30 | 3.2446 | L_Fortluft | 25.9568 | 3.54122 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 1400 | 1000 | 100 | 30 | 3.2446 | L_Fortluft | 25.9568 | 3.54122 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 1400 | 1000 | 100 | 45 | 4.6269 | L_Fortluft | 37.0152 | 4.51244 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 45 | 3.18743 | L_Fortluft | 20.3996 | 3.99076 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 45 | 3.18743 | L_Fortluft | 20.3996 | 3.99076 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 47 | 300 | 350 | 100 | 90 | 1.04892 | L_Zuluft | 5.0348 | 3.1267 | 159 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 20 | 300 | 350 | 100 | 90 | 1.04892 | L_Zuluft | 5.0348 | 3.62624 | 301 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 39 | 700 | 800 | 100 | 90 | 4.54115 | L_Zuluft | 29.0634 | 6.54996 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 39 | 700 | 800 | 100 | 90 | 4.54115 | L_Zuluft | 29.0634 | 6.54996 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 30 | 500 | 400 | 100 | 90 | 1.59372 | L_Fortluft | 7.64984 | 4.78771 | 370 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Fortluft | 10.0078 | 4.92067 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 15 | 1 | L_Fortluft | 3.83116 | 1.76317 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 15 | 1 | L_Fortluft | 2.46796 | 1.76317 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 30 | 500 | 400 | 100 | 15 | 1 | L_Fortluft | 3.33417 | 1.68174 | 393 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 30 | 500 | 400 | 100 | 15 | 1 | L_Fortluft | 1.99497 | 1.68174 | 391 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 500 | 500 | 100 | 90 | 2.08496 | L_Aussenluft | 10.0078 | 4.92067 | 267 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 400 | 100 | 90 | 1.59372 | L_Aussenluft | 7.64984 | 4.78771 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 400 | 100 | 15 | 1 | L_Aussenluft | 3.33417 | 1.68174 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 400 | 100 | 15 | 1 | L_Aussenluft | 1.99497 | 1.68174 | 46 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 39 | 800 | 700 | 100 | 45 | 2.18496 | L_Zuluft | 13.9837 | 4.98725 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 39 | 800 | 700 | 100 | 45 | 2.18496 | L_Zuluft | 13.9837 | 4.98725 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 11 | 700 | 800 | 100 | 90 | 4.54115 | L_Zuluft | 29.0634 | 7.18862 | 204 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 600 | 700 | 100 | 60 | 2.43817 | L_Abluft | 15.6043 | 4.65888 | 401 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 600 | 700 | 100 | 60 | 2.43817 | L_Abluft | 15.6043 | 4.65888 | 403 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 600 | 700 | 100 | 90 | 3.52726 | L_Zuluft | 22.5744 | 5.58597 | 376 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 600 | 700 | 100 | 45 | 1.89363 | L_Zuluft | 12.1192 | 3.69747 | 371 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 600 | 700 | 100 | 45 | 1.89363 | L_Zuluft | 12.1192 | 3.69747 | 373 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 800 | 100 | 30 | 2.6277 | L_Zuluft | 21.0216 | 4.85445 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 1000 | 1200 | 100 | 30 | 3.43498 | L_Abluft | 27.4799 | 3.59387 | 117 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 1000 | 1200 | 100 | 30 | 3.43498 | L_Abluft | 27.4799 | 3.59387 | 113 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 193 | 1400 | 2200 | 100 | 30 | 9.3908 | L_Aussenluft | 82.639 | 3.67656 | 672 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 193 | 1400 | 2200 | 100 | 30 | 9.3908 | L_Aussenluft | 82.639 | 3.67656 | 675 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 81 | 1400 | 2200 | 100 | 90 | 26.7324 | L_Fortluft | 235.245 | 5.76101 | 543 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 81 | 2200 | 1400 | 100 | 45 | 9.2023 | L_Fortluft | 80.9802 | 6.2729 | 542 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 81 | 2200 | 1400 | 100 | 45 | 9.2023 | L_Fortluft | 80.9802 | 6.2729 | 539 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 81 | 2200 | 1400 | 100 | 45 | 9.2023 | L_Fortluft | 80.9802 | 6.2729 | 546 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 81 | 2200 | 1400 | 100 | 45 | 9.2023 | L_Fortluft | 80.9802 | 6.2729 | 548 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 450 | 100 | 90 | 2.02427 | L_Fortluft | 12.9553 | 5.83189 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 450 | 100 | 45 | 1.11713 | L_Fortluft | 7.14966 | 3.81388 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 600 | 450 | 100 | 45 | 1.11713 | L_Fortluft | 7.14966 | 3.81388 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 117 | 300 | 250 | 100 | 45 | 1 | L_Zuluft | 1.97942 | 2.34847 | 264 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 117 | 300 | 250 | 100 | 45 | 1 | L_Zuluft | 1.97942 | 2.34847 | 266 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 115 | 350 | 350 | 100 | 45 | 1 | L_Zuluft | 3.04704 | 2.72099 | 236 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 115 | 350 | 350 | 100 | 45 | 1 | L_Zuluft | 3.04704 | 2.72099 | 234 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 90 | 6.01487 | L_Zuluft | 38.4951 | 6.07842 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 900 | 900 | 100 | 90 | 6.01487 | L_Abluft | 38.4951 | 6.1628 | 46 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 900 | 900 | 100 | 90 | 6.01487 | L_Abluft | 38.4951 | 6.1628 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 90 | 6.01487 | L_Zuluft | 38.4951 | 6.07842 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 25 | 600 | 1000 | 100 | 45 | 3.0846 | L_Abluft | 19.7414 | 3.04929 | 78 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 25 | 600 | 1000 | 100 | 45 | 3.0846 | L_Abluft | 19.7414 | 3.04929 | 77 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 25 | 600 | 1000 | 100 | 45 | 3.0846 | L_Abluft | 19.7414 | 3.04929 | 75 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 25 | 600 | 1000 | 100 | 45 | 3.0846 | L_Abluft | 19.7414 | 3.04929 | 74 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 1000 | 1200 | 100 | 30 | 3.43498 | L_Abluft | 27.4799 | 3.59387 | 114 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 1000 | 1200 | 100 | 30 | 3.43498 | L_Abluft | 27.4799 | 3.59387 | 116 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 800 | 100 | 30 | 2.6277 | L_Zuluft | 21.0216 | 4.85445 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Zuluft | 10.0078 | 4.92067 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 171 | 700 | 500 | 100 | 90 | 2.50195 | L_Zuluft | 16.0125 | 6.80645 | 317 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 700 | 500 | 100 | 90 | 2.50195 | L_Abluft | 16.0125 | 7.51926 | 464 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 18 | 500 | 350 | 100 | 90 | 1.37166 | L_Zuluft | 6.58396 | 4.71095 | 534 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 7 | 350 | 300 | 100 | 90 | 1 | L_Zuluft | 4.54471 | 3.77381 | 598 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 33 | 1300 | 1400 | 100 | 90 | 13.2635 | L_Zuluft | 106.108 | 5.60647 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 33 | 1300 | 1400 | 100 | 90 | 13.2635 | L_Zuluft | 106.108 | 5.60647 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 38 | 450 | 800 | 100 | 90 | 3.78429 | L_Zuluft | 24.2195 | 4.14075 | 412 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 800 | 500 | 100 | 90 | 2.71044 | L_Abluft | 17.3468 | 7.58811 | 188 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 61 | 700 | 400 | 100 | 90 | 1.94788 | L_Abluft | 12.4664 | 6.21572 | 142 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 61 | 400 | 700 | 100 | 90 | 2.9846 | L_Abluft | 19.1014 | 3.35045 | 140 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 61 | 700 | 400 | 100 | 90 | 1.94788 | L_Abluft | 12.4664 | 6.21572 | 138 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 61 | 700 | 400 | 100 | 90 | 1.94788 | L_Abluft | 12.4664 | 6.21572 | 136 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 61 | 400 | 700 | 100 | 90 | 2.9846 | L_Abluft | 19.1014 | 3.35045 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 69 | 800 | 500 | 100 | 90 | 2.71044 | L_Abluft | 17.3468 | 7.58811 | 91 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 69 | 500 | 800 | 100 | 90 | 3.93566 | L_Abluft | 25.1882 | 4.26421 | 89 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 69 | 800 | 500 | 100 | 45 | 1.48522 | L_Abluft | 9.50542 | 4.89036 | 84 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 69 | 500 | 800 | 100 | 90 | 3.93566 | L_Abluft | 25.1882 | 4.26421 | 80 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 77 | 500 | 300 | 100 | 90 | 1.16531 | L_Abluft | 5.59349 | 5.16095 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 69 | 800 | 500 | 100 | 45 | 1.48522 | L_Abluft | 9.50542 | 4.89036 | 82 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 1600 | 1800 | 100 | 90 | 20.9747 | L_Abluft | 167.798 | 5.20565 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 18 | 350 | 500 | 100 | 90 | 1.77221 | L_Zuluft | 8.50662 | 3.36777 | 530 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 500 | 600 | 100 | 90 | 2.63903 | L_Zuluft | 16.8898 | 3.8365 | 521 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 35 | 800 | 400 | 100 | 90 | 2.12496 | L_Abluft | 13.5997 | 8.10413 | 314 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 35 | 400 | 800 | 100 | 90 | 3.63292 | L_Abluft | 23.2507 | 3.63361 | 313 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 18 | 350 | 500 | 100 | 90 | 1.77221 | L_Zuluft | 8.50662 | 3.36777 | 526 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 7 | 300 | 350 | 100 | 90 | 1.04892 | L_Zuluft | 5.0348 | 3.37185 | 585 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 7 | 300 | 350 | 100 | 90 | 1.04892 | L_Zuluft | 5.0348 | 3.37185 | 588 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 43 | 300 | 550 | 100 | 90 | 1.90573 | L_Abluft | 12.1967 | 3.04707 | 276 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 47 | 300 | 350 | 100 | 90 | 1.04892 | L_Abluft | 5.0348 | 3.37185 | 249 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 47 | 350 | 300 | 100 | 90 | 1 | L_Abluft | 4.54471 | 3.77381 | 246 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 47 | 350 | 300 | 100 | 90 | 1 | L_Abluft | 4.54471 | 3.77381 | 241 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 35 | 1000 | 1200 | 100 | 90 | 9.42495 | L_Zuluft | 75.3996 | 4.33941 | 201 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 35 | 1000 | 1200 | 100 | 90 | 9.42495 | L_Zuluft | 75.3996 | 4.33941 | 200 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 1000 | 1200 | 100 | 90 | 9.42495 | L_Zuluft | 75.3996 | 5.25157 | 512 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 900 | 900 | 100 | 90 | 6.13979 | L_Abluft | 39.2946 | 6.1628 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 90 | 6.01487 | L_Zuluft | 38.4951 | 6.07842 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 90 | 6.01487 | L_Zuluft | 38.4951 | 6.07842 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 90 | 1.87646 | L_Aussenluft | 9.00701 | 3.81831 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 500 | 500 | 100 | 90 | 2.08496 | L_Aussenluft | 10.0078 | 4.92067 | 291 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 90 | 1.87646 | L_Aussenluft | 9.00701 | 3.81831 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 500 | 500 | 100 | 90 | 2.08496 | L_Aussenluft | 10.0078 | 4.92067 | 283 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 43 | 550 | 300 | 100 | 45 | 1 | L_Abluft | 4.50605 | 3.62958 | 281 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 43 | 550 | 300 | 100 | 45 | 1 | L_Abluft | 4.50605 | 3.62958 | 283 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 43 | 550 | 300 | 100 | 90 | 1.23814 | L_Abluft | 7.92411 | 5.5006 | 285 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 500 | 750 | 100 | 45 | 1.91897 | L_Zuluft | 12.2814 | 3.36762 | 642 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 500 | 750 | 100 | 45 | 1.91897 | L_Zuluft | 12.2814 | 3.36762 | 640 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 500 | 750 | 100 | 45 | 1.91897 | L_Zuluft | 12.2814 | 3.36762 | 638 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 700 | 750 | 100 | 45 | 2.22601 | L_Zuluft | 14.2464 | 4.25586 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 72 | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 8.04755 | 78 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 7 | 700 | 750 | 100 | 45 | 2.22601 | L_Zuluft | 14.2464 | 4.25586 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 6 | 700 | 750 | 100 | 45 | 2.22601 | L_Zuluft | 14.2464 | 4.25586 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 7 | 700 | 750 | 100 | 45 | 2.22601 | L_Zuluft | 14.2464 | 4.25586 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 62 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 60 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 69 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 10 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 9 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 10 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 9 | 800 | 750 | 100 | 45 | 2.37952 | L_Zuluft | 15.229 | 4.65443 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 11 | 700 | 800 | 100 | 90 | 4.54115 | L_Zuluft | 29.0634 | 7.18862 | 197 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 11 | 800 | 700 | 100 | 45 | 2.18496 | L_Zuluft | 13.9837 | 5.47354 | 198 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 11 | 800 | 700 | 100 | 45 | 2.18496 | L_Zuluft | 13.9837 | 5.47354 | 200 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 1400 | 100 | 45 | 7.41296 | L_Aussenluft | 59.3037 | 7.48481 | 97 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 1400 | 100 | 45 | 7.41296 | L_Aussenluft | 59.3037 | 7.48481 | 99 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 1400 | 100 | 45 | 7.41296 | L_Aussenluft | 59.3037 | 7.48481 | 101 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 8 | 1500 | 1400 | 100 | 45 | 7.41296 | L_Aussenluft | 59.3037 | 7.48481 | 103 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 45 | 3.18743 | L_Aussenluft | 20.3996 | 3.99076 | 889 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 45 | 3.18743 | L_Aussenluft | 20.3996 | 3.99076 | 891 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 45 | 3.18743 | L_Aussenluft | 20.3996 | 3.99076 | 894 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 45 | 3.18743 | L_Aussenluft | 20.3996 | 3.99076 | 896 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 500 | 500 | 100 | 15 | 1 | L_Aussenluft | 3.83116 | 1.76317 | 295 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 500 | 500 | 100 | 15 | 1 | L_Aussenluft | 3.83116 | 1.76317 | 293 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 600 | 450 | 100 | 30 | 1 | L_Aussenluft | 5.21444 | 3.05713 | 138 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 600 | 450 | 100 | 30 | 1 | L_Aussenluft | 5.21444 | 3.05713 | 140 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 500 | 750 | 100 | 45 | 1.91897 | L_Zuluft | 12.2814 | 3.36762 | 636 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 90 | 3.83858 | L_Zuluft | 24.5669 | 8.88794
3 x Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 90 | 3.83858 | L_Zuluft | 24.5669
Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 90 | 3.80658 | L_Zuluft | 24.3621
2 x Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 15 | 1 | L_Zuluft | 5.80116
Bogen symmetrisch | Wartung_FFB |  | 1500 | 800 | 100 | 30 | 3.2349 | L_Zuluft | 25.8792
Bogen symmetrisch | Wartung_FFB |  | 1500 | 800 | 100 | 30 | 2.6277 | L_Zuluft | 21.0216
2 x Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 90 | 3.80658 | L_Zuluft | 24.3621 | 8.88794
Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 30 | 2.60006 | L_Zuluft | 16.6404 | 4.47807
2 x Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 30 | 1.49286 | L_Zuluft | 9.55431 | 4.47807
Bogen symmetrisch | Wartung_FFB |  | 1000 | 600 | 100 | 30 | 2.12326 | L_Zuluft | 13.5889 | 4.47807
2 x Bogen symmetrisch | Wartung_FFB |  | 1500 | 800 | 100 | 15 | 1.54385 | L_Zuluft | 12.3508 | 2.92863
Bogen symmetrisch | Wartung_FFB |  | 1500 | 800 | 100 | 15 | 1.64965 | L_Zuluft | 13.1972
Bogen symmetrisch | Wartung_FFB |  | 1500 | 800 | 100 | 15 | 1.54385 | L_Zuluft | 12.3508
Bogen symmetrisch | Wartung_FFB |  | 1500 | 700 | 100 | 45 | 3.2046 | L_Zuluft | 25.6368 | 6.17473
Bogen symmetrisch | Wartung_FFB |  | 1000 | 500 | 100 | 60 | 3.08196 | L_Zuluft | 19.7245 | 7.89972
Bogen symmetrisch | Wartung_FFB |  | 1000 | 500 | 100 | 60 | 2.18496 | L_Zuluft | 13.9837 | 7.89972
Bogen symmetrisch | Wartung_FFB |  | 1000 | 500 | 100 | 45 | 2.26272 | L_Zuluft | 14.4814 | 6.30056
Bogen symmetrisch | Wartung_FFB |  | 1000 | 500 | 100 | 45 | 1.71372 | L_Zuluft | 10.9678 | 6.30056
Bogen symmetrisch | Wartung_FFB |  | 1000 | 500 | 100 | 30 | 1.63848 | L_Zuluft | 10.4863 | 4.96793
Bogen symmetrisch | Wartung_FFB |  | 1000 | 500 | 100 | 30 | 1.24248 | L_Zuluft | 7.95186 | 4.96793
Bogen symmetrisch | Wartung_FFB |  | 1500 | 700 | 100 | 30 | 3.42267 | L_Zuluft | 27.3813
Bogen symmetrisch | Wartung_FFB |  | 1500 | 700 | 100 | 30 | 2.28307 | L_Zuluft | 18.2645
Bogen symmetrisch | Wartung_FFB |  | 750 | 500 | 100 | 45 | 1.7031 | L_Zuluft | 10.8998 | 5.23248
Bogen symmetrisch | Wartung_FFB |  | 750 | 500 | 100 | 45 | 1.4281 | L_Zuluft | 9.13982 | 5.23248
3 x Bogen symmetrisch | Wartung_FFB |  | 750 | 500 | 100 | 30 | 1.0354 | L_Zuluft | 6.62655 | 4.16104
2 x Bogen symmetrisch | Wartung_FFB |  | 1500 | 500 | 100 | 15 | 1.02832 | L_Zuluft | 8.22655
2 x Bogen symmetrisch | Wartung_FFB |  | 750 | 500 | 100 | 15 | 1 | L_Zuluft | 4.11327 | 2.60745
Bogen symmetrisch | Wartung_FFB |  | 750 | 500 | 100 | 30 | 1.5179 | L_Zuluft | 9.71455 | 4.16104
2 x Bogen symmetrisch | Wartung_FFB |  | 500 | 500 | 100 | 15 | 1 | L_Abluft | 2.46796 | 1.76317
Bogen symmetrisch | Wartung_FFB |  | 500 | 300 | 100 | 90 | 1.16531 | L_Abluft | 5.59349 | 5.16095
Bogen symmetrisch | Wartung_FFB |  | 300 | 500 | 100 | 90 | 1.66796 | L_Abluft | 8.00623 | 3.22705
Bogen symmetrisch | Wartung_FFB |  | 800 | 450 | 100 | 90 | 2.40984 | L_Zuluft | 15.423 | 8.18488
Bogen symmetrisch | Wartung_FFB |  | 1300 | 1400 | 100 | 90 | 13.2964 | L_Zuluft | 106.371 | 5.60647
Bogen symmetrisch | Wartung_FFB | 17 | 500 | 400 | 100 | 90 | 1.59372 | L_Abluft | 7.64984 | 5.45273 | 386 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Bogen symmetrisch | Wartung_FFB |  | 600 | 500 | 100 | 90 | 2.29345 | L_Abluft | 14.6781 | 6.20325
2 x Bogen symmetrisch | Wartung_FFB |  | 500 | 600 | 100 | 45 | 1.42951 | L_Abluft | 9.14888 | 3.33011
2 x Bogen symmetrisch | Wartung_FFB |  | 600 | 500 | 100 | 90 | 2.29345 | L_Zuluft | 14.6781
Bogen symmetrisch | Wartung_FFB |  | 500 | 350 | 100 | 90 | 1.37166 | L_Zuluft | 6.58396
Bogen symmetrisch | Wartung_FFB |  | 500 | 600 | 100 | 45 | 1.42951 | L_Zuluft | 9.14888
2 x Bogen symmetrisch | Wartung_FFB | 34 | 1000 | 1200 | 100 | 45 | 4.93248 | L_Zuluft | 39.4598 | 3.83867 | 116 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Bogen symmetrisch | Wartung_FFB |  | 300 | 250 | 100 | 15 | 1 | L_Zuluft | 1.01181
Bogen symmetrisch | Wartung_FFB | 61 | 500 | 800 | 100 | 90 | 3.93566 | L_Abluft | 25.1882 | 3.35045 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB |  | 500 | 800 | 0 | 90 | 3.98226 | L_Abluft | 25.4864
2 x Bogen symmetrisch | Wartung_FFB |  | 500 | 400 | 100 | 15 | 1 | L_Zuluft | 1.99497
Bogen symmetrisch | Wartung_FFB |  | 500 | 400 | 100 | 90 | 1.59372 | L_Zuluft | 7.64984 | 5.23633
Bogen symmetrisch | EG_Verwaltung_FFB | 24 | 300 | 300 | 100 | 90 | 1 | L_Zuluft | 4.19511 | 2.46481 | 650 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 26 | 300 | 300 | 100 | 90 | 1 | L_Abluft | 4.19511 | 2.46481 | 705 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 25 | 250 | 300 | 100 | 90 | 1 | L_Zuluft | 3.84552 | 2.34014 | 668 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 25 | 250 | 300 | 100 | 90 | 1 | L_Zuluft | 3.84552 | 2.34014 | 670 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 27 | 250 | 300 | 100 | 90 | 1 | L_Abluft | 3.84552 | 2.34014 | 722 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 27 | 250 | 300 | 100 | 90 | 1 | L_Abluft | 3.84552 | 2.34014 | 720 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 60 | 650 | 500 | 50 | 90 | 2.21706 | L_Zuluft | 14.1892 | 9.17063 | 36 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 61 | 650 | 500 | 50 | 90 | 2.21706 | L_Abluft | 14.1892 | 9.17063 | 60 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 10 | 200 | 250 | 100 | 90 | 1 | L_Zuluft | 2.80704 | 2.0187 | 524 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 20 | 200 | 250 | 100 | 90 | 1 | L_Abluft | 2.80704 | 2.0187 | 518 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 500 | 200 | 100 | 90 | 1 | L_Abluft | 3.83873 | 4.43497 | 428 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 8 | 500 | 200 | 100 | 90 | 1 | L_Zuluft | 3.83873 | 4.43497 | 431 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 8 | 500 | 200 | 100 | 90 | 1 | L_Zuluft | 3.83873 | 4.43497 | 429 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 500 | 200 | 100 | 90 | 1 | L_Abluft | 3.83873 | 4.43497 | 426 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 6 | 300 | 600 | 100 | 90 | 2.1592 | L_Abluft | 13.8189 | 2.39082 | 84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 2 | 600 | 450 | 100 | 90 | 2.02427 | L_Zuluft | 12.9553 | 5.83189 | 10 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 5 | 300 | 600 | 100 | 90 | 2.1592 | L_Zuluft | 13.8189 | 2.39082 | 53 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 6 | 200 | 300 | 100 | 90 | 1 | L_Zuluft | 3.49593 | 2.39278 | 318 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 5 | 200 | 300 | 100 | 90 | 1 | L_Abluft | 3.49593 | 2.39278 | 295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 4 | 350 | 300 | 100 | 90 | 1 | L_Abluft | 4.54471 | 3.3398 | 205 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 3 | 300 | 400 | 100 | 90 | 1.23956 | L_Abluft | 5.94988 | 3.49276 | 146 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 4 | 300 | 400 | 100 | 90 | 1.23956 | L_Zuluft | 5.94988 | 3.23413 | 184 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 21 | 200 | 300 | 100 | 90 | 1 | L_Zuluft | 3.49593 | 2.58803 | 108 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 10 | 200 | 200 | 100 | 90 | 1 | L_Abluft | 2.19356 | 2.15367 | 249 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 18 | 300 | 350 | 100 | 90 | 1.04892 | L_Abluft | 5.0348 | 1.77686 | 142 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 200 | 300 | 100 | 90 | 1 | L_Zuluft | 3.49593 | 2.29803 | 105 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 450 | 700 | 100 | 90 | 3.24654 | L_Abluft | 20.7778 | 3.46307 | 415 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 3 | 600 | 450 | 100 | 90 | 2.02427 | L_Abluft | 12.9553 | 5.83189 | 45 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 7 | 250 | 200 | 100 | 30 | 1 | L_Zuluft | 1.11058 | 1.27589 | 802 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 7 | 250 | 200 | 100 | 30 | 1 | L_Zuluft | 1.11058 | 1.27589 | 804 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 172 | 700 | 500 | 100 | 90 | 2.50195 | L_Zuluft | 16.0125 | 6.80645 | 323 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 14 | 200 | 400 | 50 | 90 | 1 | L_Abluft | 4.6475 | 2.30489 | 491 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 9 | 200 | 200 | 100 | 90 | 1 | L_Abluft | 2.19356 | 2.38829 | 512 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 19 | 500 | 350 | 100 | 90 | 1.37166 | L_Zuluft | 6.58396 | 4.71095 | 539 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 78 | 500 | 300 | 100 | 90 | 1.16531 | L_Abluft | 5.59349 | 5.16095 | 61 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 75 | 250 | 400 | 100 | 90 | 1.15102 | L_Abluft | 5.52488 | 3.01282 | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 64 | 400 | 200 | 100 | 90 | 1 | L_Abluft | 3.29034 | 2.77734 | 176 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 64 | 200 | 400 | 100 | 90 | 1.06248 | L_Abluft | 5.09989 | 1.95703 | 174 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 67 | 400 | 200 | 100 | 90 | 1 | L_Abluft | 3.29034 | 2.77734 | 158 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 67 | 200 | 400 | 100 | 90 | 1.06248 | L_Abluft | 5.09989 | 1.95703 | 156 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 59 | 250 | 400 | 100 | 90 | 1.15102 | L_Abluft | 5.52488 | 3.01282 | 205 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 56 | 250 | 400 | 100 | 90 | 1.15102 | L_Abluft | 5.52488 | 3.01282 | 225 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 36 | 800 | 400 | 100 | 90 | 2.12496 | L_Abluft | 13.5997 | 8.10413 | 320 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 46 | 400 | 200 | 100 | 90 | 1 | L_Abluft | 3.29034 | 4.14887 | 295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 45 | 400 | 200 | 100 | 90 | 1 | L_Abluft | 3.29034 | 4.14887 | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 45 | 200 | 400 | 100 | 90 | 1.06248 | L_Abluft | 5.09989 | 2.92347 | 301 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 46 | 200 | 400 | 100 | 90 | 1.06248 | L_Abluft | 5.09989 | 2.92347 | 293 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 48 | 350 | 300 | 100 | 90 | 1 | L_Abluft | 4.54471 | 3.77381 | 254 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 8 | 200 | 300 | 100 | 90 | 1 | L_Zuluft | 3.49641 | 2.3294 | 180 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 7 | 300 | 250 | 100 | 30 | 1 | L_Zuluft | 1.49561 | 1.45255 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 8 | 300 | 200 | 100 | 45 | 1 | L_Zuluft | 1.61097 | 1.99716 | 179 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 24 | 200 | 200 | 100 | 45 | 1 | L_Zuluft | 1.28878 | 1.5701 | 47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 24 | 200 | 200 | 100 | 45 | 1 | L_Zuluft | 1.28878 | 1.5701 | 49 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 8 | 300 | 200 | 100 | 45 | 1 | L_Abluft | 1.61097 | 2.57341 | 202 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 8 | 300 | 200 | 100 | 45 | 1 | L_Abluft | 1.61097 | 2.57341 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 10 | 200 | 200 | 100 | 30 | 1 | L_Abluft | 0.987186 | 1.35126 | 245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 15 | 500 | 300 | 100 | 15 | 1.04115 | L_Abluft | 4.99753 | 1.75908 | 66 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 15 | 500 | 300 | 100 | 15 | 1 | L_Abluft | 1.57225 | 1.75908 | 67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 25 | 200 | 200 | 100 | 45 | 1 | L_Abluft | 1.28878 | 1.5701 | 94 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 25 | 200 | 200 | 100 | 45 | 1 | L_Abluft | 1.28878 | 1.5701 | 96 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 12 | 200 | 200 | 100 | 45 | 1 | L_Zuluft | 1.28878 | 1.38373 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 12 | 200 | 200 | 100 | 45 | 1 | L_Zuluft | 1.28878 | 1.38373 | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 5 | 300 | 200 | 100 | 45 | 1 | L_Abluft | 1.61097 | 2.0515 | 267 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 300 | 600 | 100 | 90 | 2.1592 | L_Zuluft | 13.8189 | 3.26262 | 429 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 300 | 600 | 100 | 90 | 2.1592 | L_Zuluft | 13.8189 | 3.26262 | 431 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 13 | 400 | 600 | 100 | 90 | 2.39911 | L_Abluft | 15.3543 | 3.92324 | 192 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 13 | 400 | 600 | 100 | 90 | 2.39911 | L_Abluft | 15.3543 | 3.92324 | 190 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 4 | 450 | 600 | 100 | 90 | 2.51907 | L_Zuluft | 16.1221 | 3.47172 | 198 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 0 | 90 | 1 | L_Zuluft | 1.59037 | 8.18148 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 100 | 45 | 1 | L_Zuluft | 1.28878 | 1.44454 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 4 | 350 | 650 | 100 | 90 | 2.55619 | L_Zuluft | 16.3596 | 3.60961 | 201 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 5 | 350 | 500 | 0 | 90 | 1.78721 | L_Zuluft | 8.57859 | 6.93686 | 382 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 14 | 350 | 500 | 0 | 90 | 1.78891 | L_Abluft | 8.58675 | 6.93686 | 372 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 5 | 300 | 200 | 100 | 45 | 1 | L_Abluft | 1.61097 | 2.0515 | 269 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 19 | 200 | 200 | 100 | 45 | 1 | L_Abluft | 1.28878 | 1.5701 | 167 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 19 | 200 | 200 | 100 | 45 | 1 | L_Abluft | 1.28878 | 1.5701 | 169 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 15 | 300 | 500 | 100 | 30 | 1 | L_Abluft | 3.18074 | 1.82942 | 69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 15 | 300 | 500 | 100 | 30 | 1 | L_Abluft | 3.18074 | 1.82942 | 71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 100 | 90 | 1 | L_Abluft | 2.29301 | 1.674
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 100 | 90 | 1 | L_Abluft | 2.58255 | 1.66626
Bogen symmetrisch | EG_Verwaltung_FFB | 191 | 400 | 450 | 100 | 60 | 1.14913 | L_Zuluft | 5.51582 | 2.01638 | 327 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB | 191 | 400 | 450 | 100 | 30 | 1 | L_Zuluft | 3.16591 | 2.01638 | 327 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen symmetrisch | EG_Verwaltung_FFB |  | 800 | 450 | 100 | 90 | 2.40984 | L_Zuluft | 15.423 | 8.18488
Bogen symmetrisch | EG_Verwaltung_FFB |  | 250 | 400 | 100 | 90 | 1.15102 | L_Abluft | 5.52488 | 1.65313
2 x Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 400 | 100 | 90 | 1.23956 | L_Abluft | 5.94988 | 1.74856
Bogen symmetrisch | EG_Verwaltung_FFB | 164 | 800 | 500 | 100 | 90 | 2.71044 | L_Zuluft | 17.3468 | 8.65758 | 34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB |  | 450 | 350 | 100 | 90 | 1.29097 | L_Zuluft | 6.19667 | 5.10584
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 400 | 100 | 90 | 1.59372 | L_Zuluft | 7.64984 | 6.22125
Bogen symmetrisch | EG_Verwaltung_FFB |  | 350 | 300 | 50 | 90 | 1 | L_Zuluft | 4.05462 | 6.09536
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 350 | 50 | 90 | 1 | L_Zuluft | 4.54471 | 4.94382
3 x Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 350 | 100 | 90 | 1.04892 | L_Abluft | 5.0348 | 3.37185
Bogen symmetrisch | EG_Verwaltung_FFB |  | 350 | 300 | 100 | 90 | 1 | L_Abluft | 4.54471 | 3.77381
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 350 | 100 | 90 | 1.21029 | L_Zuluft | 5.80938
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 200 | 100 | 90 | 1 | L_Abluft | 2.74195
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 200 | 100 | 90 | 1 | L_Abluft | 3.65923
Bogen symmetrisch | EG_Verwaltung_FFB |  | 250 | 200 | 100 | 15 | 1 | L_Abluft | 1.78217
Bogen symmetrisch | EG_Verwaltung_FFB |  | 250 | 200 | 100 | 15 | 1 | L_Abluft | 0.771292
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 650 | 100 | 15 | 1 | L_Abluft | 3.70089
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 650 | 100 | 15 | 1 | L_Abluft | 3.60361
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 500 | 100 | 30 | 1 | L_Zuluft | 4.20779
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 500 | 100 | 30 | 1 | L_Zuluft | 2.78315
Bogen symmetrisch | EG_Verwaltung_FFB |  | 600 | 400 | 100 | 30 | 1.0156 | L_Abluft | 6.49983
Bogen symmetrisch | EG_Verwaltung_FFB |  | 600 | 400 | 100 | 30 | 1 | L_Abluft | 4.63103
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 100 | 30 | 1 | L_Abluft | 1.42034
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 200 | 0 | 45 | 1 | L_Zuluft | 1.27766
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 200 | 100 | 15 | 1 | L_Zuluft | 1.86935
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 200 | 100 | 15 | 1 | L_Zuluft | 1.02839
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 250 | 100 | 30 | 1 | L_Zuluft | 3.78396
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 250 | 100 | 15 | 1 | L_Zuluft | 1.19133
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 250 | 100 | 15 | 1 | L_Zuluft | 1.01181
Bogen symmetrisch | EG_Verwaltung_FFB | 17 | 300 | 200 | 100 | 60 | 1 | L_Zuluft | 1.74796 | 1.97027 | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | EG_Verwaltung_FFB |  | 300 | 200 | 100 | 60 | 1 | L_Zuluft | 2.39932
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 300 | 100 | 15 | 1 | L_Abluft | 1.77961
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 300 | 100 | 15 | 1 | L_Abluft | 1.57225
2 x Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 300 | 100 | 15 | 1 | L_Abluft | 0.982655
4 x Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 300 | 100 | 15 | 1 | L_Zuluft | 0.982655
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 100 | 15 | 1 | L_Abluft | 0.693273
Bogen symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 100 | 15 | 1 | L_Abluft | 0.685593
Bogen symmetrisch | EG_Verwaltung_FFB |  | 600 | 400 | 100 | 15 | 1 | L_Abluft | 5.60512
Bogen symmetrisch | EG_Verwaltung_FFB |  | 600 | 400 | 100 | 15 | 1 | L_Abluft | 2.95552
Bogen symmetrisch | EG_Verwaltung_FFB |  | 650 | 350 | 100 | 15 | 1.37162 | L_Zuluft | 8.77836
Bogen symmetrisch | EG_Verwaltung_FFB |  | 650 | 350 | 100 | 15 | 1 | L_Zuluft | 2.78796
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 200 | 100 | 15 | 1 | L_Abluft | 2.77227
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 200 | 100 | 15 | 1 | L_Abluft | 1.19979
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 200 | 100 | 15 | 1 | L_Zuluft | 2.77227
Bogen symmetrisch | EG_Verwaltung_FFB |  | 500 | 200 | 100 | 15 | 1 | L_Zuluft | 1.19979
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 350 | 100 | 15 | 1 | L_Abluft | 3.66343
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 350 | 100 | 15 | 1 | L_Abluft | 1.56823
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 400 | 100 | 15 | 1 | L_Zuluft | 3.96211
Bogen symmetrisch | EG_Verwaltung_FFB |  | 400 | 400 | 100 | 15 | 1 | L_Zuluft | 1.77331

# IfcFlowFitting: Enddeckel (16)
In: EG_Verwaltung_FFB
Description: Enddeckel
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Medium: L_Umluft; Tech-Material (ID): 1; Name: Enddeckel; Abbreviation: DRE; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Diameter (mm) (mm) | Geom-Length (mm) (mm)
8 x Enddeckel | 250 | 60
8 x Enddeckel | 200 | 40

# IfcFlowFitting: Gemeinsamer Rahmen (9)
Description: Gemeinsamer Rahmen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Gemeinsamer Rahmen; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Section No | Geom-Small side (mm) (mm) | Geom-Big side (mm) (mm) | Tech-Medium | Pos. No. | Floor | Floor No.
Gemeinsamer Rahmen | Wartung_FFB | 1 | 1400 | 2000 | L_Fortluft | 33 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 6 | 500 | 600 | L_Zuluft | 522 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 52 | 1000 | 1600 | L_Abluft | 41 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 34 | 800 | 1000 | L_Abluft | 234 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 5 | 700 | 1500 | L_Zuluft | 27 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 2 | 800 | 1500 | L_Zuluft | 52 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 8 | 800 | 1500 | L_Zuluft | 23 | Wartung_FFB | 2
Gemeinsamer Rahmen | Wartung_FFB | 3 | 500 | 1500 | L_Zuluft | 631 | Wartung_FFB | 2
Gemeinsamer Rahmen | EG_Verwaltung_FFB | 56 | 200 | 350 | L_Zuluft | 389 | EG_Verwaltung_FFB | 0

# IfcFlowFitting: Hosenstück (2)
In: EG_Verwaltung_FFB
Description: Hosenstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Thickness (mm): 200 mm; Geom-Main side (mm): 250 mm; Geom-Secondary side 1 (mm): 150 mm; Geom-Secondary side 2 (mm): 150 mm; Geom-Distance between branches (mm): 100 mm; Geom-Length (mm): 500 mm; Geom-Surface (m2): 1 m2; Tech-Weight (kg): 2.91222 kg; Tech-Material (ID): 1; Name: Hosenstück; Abbreviation: HS; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Tech-Medium | Pos. No.
Hosenstück | 7 | L_Zuluft | 358
Hosenstück | 6 | L_Abluft | 340

# IfcFlowFitting: Konisches Übergangsstück (214)
Description: Konisches Übergangsstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Offset (mm): 0 mm; Tech-Material (ID): 1; Name: Konisches Übergangsstück; Abbreviation: USE
Name | In | Section No | Geom-Main diameter (mm) (mm) | Geom-Secondary diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Konisches Übergangsstück | Wartung_FFB | 1 | 630 | 450 | 287 | L_Abluft | 2.13211 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 1 | 450 | 400 | 109 | L_Abluft | 1.00923 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 85 | 250 | 160 | 154 | L_Zuluft | 4.88129 | 478 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 119 | 250 | 160 | 154 | L_Zuluft | 4.88129 | 299 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 50 | 250 | 160 | 154 | L_Zuluft | 4.88129 | 188 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 23 | 250 | 160 | 154 | L_Zuluft | 6.49876 | 339 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 51 | 140 | 100 | 85 | L_Abluft | 0.546437 | 154 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 55 | 140 | 100 | 85 | L_Abluft | 0.546437 | 101 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 50 | 140 | 100 | 85 | L_Zuluft | 1.99685 | 72 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 49 | 180 | 140 | 85 | L_Zuluft | 1.40626 | 42 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 54 | 180 | 140 | 85 | L_Abluft | 0.463568 | 74 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 44 | 250 | 200 | 99 | L_Zuluft | 2.0537 | 153 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 1 | 400 | 560 | 260 | L_Abluft | 5.3363 | 3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | Wartung_FFB | 1 | 560 | 630 | 136 | L_Abluft | 0.410487 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 37 | 160 | 200 | 85 | L_Zuluft | 0.29038 | 647 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 39 | 160 | 200 | 85 | L_Abluft | 0.85514 | 702 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 40 | 100 | 160 | 112 | L_Abluft | 3.92117 | 682 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 38 | 100 | 160 | 112 | L_Zuluft | 0.720827 | 627 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 53 | 125 | 160 | 78 | L_Zuluft | 0.258101 | 446 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 56 | 125 | 160 | 78 | L_Abluft | 0.771252 | 466 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 37 | 140 | 200 | 112 | L_Abluft | 2.67151 | 734 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 35 | 140 | 200 | 112 | L_Zuluft | 0.583008 | 685 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 32 | 125 | 160 | 78 | L_Zuluft | 0.216877 | 733 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 33 | 125 | 160 | 78 | L_Abluft | 0.648066 | 787 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 30 | 125 | 160 | 78 | L_Zuluft | 0.30291 | 765 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 36 | 140 | 200 | 112 | L_Abluft | 2.28581 | 747 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 34 | 140 | 200 | 112 | L_Zuluft | 0.498836 | 702 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 34 | 140 | 200 | 112 | L_Abluft | 2.28581 | 771 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 31 | 140 | 200 | 112 | L_Zuluft | 0.498836 | 748 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 30 | 200 | 125 | 133 | L_Zuluft | 2.24826 | 752 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 38 | 125 | 160 | 78 | L_Abluft | 0.90515 | 717 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 41 | 160 | 200 | 85 | L_Zuluft | 0.29038 | 590 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 42 | 160 | 200 | 85 | L_Abluft | 0.85514 | 649 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 39 | 160 | 200 | 85 | L_Zuluft | 0.29038 | 613 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 41 | 160 | 200 | 85 | L_Abluft | 0.85514 | 670 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 32 | 200 | 125 | 133 | L_Abluft | 0.412375 | 791 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 46 | 160 | 125 | 78 | L_Zuluft | 0.771252 | 526 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 47 | 125 | 100 | 64 | L_Zuluft | 0.398179 | 546 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 43 | 125 | 160 | 78 | L_Abluft | 1.04976 | 632 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 42 | 125 | 160 | 78 | L_Zuluft | 0.351304 | 580 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 100 | 160 | 112 | L_Abluft | 3.92117 | 876 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 125 | 160 | 78 | L_Abluft | 0.90515 | 911 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
