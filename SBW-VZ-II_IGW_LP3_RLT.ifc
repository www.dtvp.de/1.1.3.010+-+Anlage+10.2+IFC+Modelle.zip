Properties of the parts of a building model (IFC2X3), part 2 of 18

# IfcFlowFitting: Bogen (860)
Name | In | Section No | Geom-Diameter (mm) (mm) = Geom-Radius (mm) (mm) | Geom-Angle (°) (rad) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Abbreviation | Floor | Floor No. | Building = Building No.
Bogen | Wartung_FFB | 89 | 160 | 45 | L_Zuluft | 2.32936 | 436 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 61 | 160 | 45 | L_Zuluft | 2.73377 | 92 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 47 | 100 | 90 | L_Zuluft | 2.32663 | 121 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Abluft | 2.32663 | 151 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Abluft | 2.32663 | 143 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Abluft | 2.32663 | 149 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 47 | 100 | 90 | L_Zuluft | 2.32663 | 111 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 47 | 100 | 90 | L_Zuluft | 2.32663 | 115 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 47 | 100 | 90 | L_Zuluft | 2.32663 | 117 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 47 | 100 | 90 | L_Zuluft | 2.32663 | 119 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 100 | 90 | L_Zuluft | 2.32663 | 80 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 55 | 100 | 90 | L_Abluft | 2.32663 | 110 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 55 | 100 | 90 | L_Abluft | 2.32663 | 122 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 100 | 90 | L_Zuluft | 2.32663 | 87 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 100 | 90 | L_Zuluft | 2.32663 | 89 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 55 | 100 | 90 | L_Abluft | 2.32663 | 116 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 55 | 100 | 90 | L_Abluft | 2.32663 | 120 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Zuluft | 2.32663 | 69 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 56 | 100 | 90 | L_Abluft | 2.32663 | 98 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 56 | 100 | 90 | L_Abluft | 2.32663 | 96 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Zuluft | 2.32663 | 63 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Zuluft | 2.32663 | 65 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Zuluft | 2.32663 | 67 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 49 | 140 | 45 | L_Zuluft | 1.76613 | 55 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 49 | 140 | 45 | L_Zuluft | 1.76613 | 53 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 49 | 140 | 45 | L_Zuluft | 1.76613 | 51 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 140 | 45 | L_Abluft | 1.76613 | 87 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 140 | 45 | L_Abluft | 1.76613 | 85 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 140 | 45 | L_Abluft | 1.76613 | 83 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 140 | 90 | L_Abluft | 2.42257 | 126 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 140 | 90 | L_Abluft | 2.42257 | 128 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 48 | 180 | 90 | L_Zuluft | 1.99471 | 7 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 53 | 180 | 90 | L_Abluft | 1.99471 | 42 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 53 | 180 | 90 | L_Abluft | 1.99471 | 44 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 48 | 180 | 90 | L_Zuluft | 1.99471 | 9 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 48 | 180 | 45 | L_Zuluft | 1.45421 | 12 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 53 | 180 | 45 | L_Abluft | 1.45421 | 47 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 39 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 100 | 90 | L_Abluft | 2.32663 | 71 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 100 | 90 | L_Abluft | 2.32663 | 69 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 33 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 35 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 37 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 140 | 90 | L_Abluft | 2.42257 | 76 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 100 | 90 | L_Abluft | 2.32663 | 62 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 27 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 100 | 90 | L_Abluft | 2.32663 | 60 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 25 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 140 | 160 | 45 | L_Zuluft | 2.73377 | 125 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 140 | 160 | 45 | L_Zuluft | 2.73377 | 127 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 140 | 45 | L_Abluft | 1.76613 | 138 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 49 | 140 | 90 | L_Zuluft | 2.42257 | 44 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 45 | L_Abluft | 1.69619 | 168 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 45 | L_Abluft | 1.69619 | 166 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 45 | L_Abluft | 1.69619 | 163 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 45 | L_Abluft | 1.69619 | 161 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 45 | L_Abluft | 1.69619 | 159 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 45 | L_Abluft | 1.69619 | 157 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 48 | 180 | 45 | L_Zuluft | 1.45421 | 14 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 53 | 180 | 45 | L_Abluft | 1.45421 | 49 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 22 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 100 | 90 | L_Abluft | 2.32663 | 57 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 140 | 45 | L_Abluft | 1.76613 | 81 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 49 | 140 | 45 | L_Zuluft | 1.76613 | 49 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 65 | 160 | 45 | L_Zuluft | 2.73377 | 58 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 65 | 160 | 45 | L_Zuluft | 2.73377 | 60 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 63 | 160 | 45 | L_Zuluft | 2.73377 | 77 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 67 | 160 | 45 | L_Zuluft | 2.73377 | 44 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 67 | 160 | 45 | L_Zuluft | 2.73377 | 46 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 46 | 100 | 90 | L_Zuluft | 2.32663 | 150 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Abluft | 2.32663 | 182 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Abluft | 2.32663 | 180 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 46 | 100 | 90 | L_Zuluft | 2.32663 | 144 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 46 | 100 | 90 | L_Zuluft | 2.32663 | 146 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 46 | 100 | 90 | L_Zuluft | 2.32663 | 148 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Abluft | 2.32663 | 174 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Abluft | 2.32663 | 172 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 44 | 200 | 90 | L_Zuluft | 4.0847 | 167 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 44 | 200 | 90 | L_Zuluft | 4.0847 | 164 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 44 | 200 | 45 | L_Zuluft | 2.97788 | 162 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 44 | 200 | 45 | L_Zuluft | 2.97788 | 160 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 44 | 200 | 45 | L_Zuluft | 2.97788 | 158 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 44 | 200 | 45 | L_Zuluft | 2.97788 | 156 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 46 | 100 | 90 | L_Zuluft | 2.32663 | 140 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 43 | 250 | 45 | L_Zuluft | 1.72344 | 135 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 43 | 250 | 45 | L_Zuluft | 1.72344 | 133 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 43 | 250 | 45 | L_Zuluft | 1.72344 | 130 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 43 | 250 | 45 | L_Zuluft | 1.72344 | 128 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 43 | 250 | 45 | L_Zuluft | 1.72344 | 126 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 43 | 250 | 45 | L_Zuluft | 1.72344 | 124 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 42 | 250 | 45 | L_Zuluft | 2.31399 | 106 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 42 | 250 | 90 | L_Zuluft | 3.17405 | 94 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 42 | 250 | 90 | L_Zuluft | 3.17405 | 96 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 52 | 100 | 90 | L_Zuluft | 2.32663 | 29 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 100 | 90 | L_Abluft | 2.32663 | 64 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 56 | 100 | 90 | L_Abluft | 2.32663 | 91 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 51 | 100 | 90 | L_Zuluft | 2.32663 | 59 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 100 | 90 | L_Zuluft | 2.32663 | 91 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 100 | 90 | L_Zuluft | 2.32663 | 82 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 55 | 100 | 90 | L_Abluft | 2.32663 | 112 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x Bogen | Wartung_FFB |  | 250 | 45 | L_Zuluft |  |  | BGE
2 x Bogen | Wartung_FFB |  | 400 | 15 | L_Abluft |  |  | BGE
Bogen | Wartung_FFB | 50 | 250 | 90 | L_Zuluft | 2.42257 | 131 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 140 | 90 | L_Abluft | 2.42257 | 131 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB |  | 250 | 15 | L_Zuluft |  |  | BGE
Bogen | Wartung_FFB |  | 140 | 15 | L_Abluft |  |  | BGE
Bogen | Wartung_FFB |  | 140 | 45 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 37 | 160 | 90 | L_Zuluft | 1.71828 | 644 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 39 | 160 | 90 | L_Abluft | 1.71828 | 699 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 40 | 100 | 90 | L_Abluft | 2.81523 | 679 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 100 | 90 | L_Zuluft | 2.81523 | 623 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 100 | 90 | L_Zuluft | 2.81523 | 625 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 125 | 90 | L_Zuluft | 1.3723 | 442 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 125 | 90 | L_Zuluft | 1.3723 | 444 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 56 | 125 | 90 | L_Abluft | 1.3723 | 463 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 608 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 556 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 610 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 612 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 558 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 562 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 614 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 564 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 140 | 90 | L_Zuluft | 2.42257 | 679 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 140 | 90 | L_Zuluft | 2.42257 | 683 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Zuluft | 1.15312 | 729 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Zuluft | 1.15312 | 731 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Zuluft | 1.15312 | 727 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 33 | 125 | 45 | L_Abluft | 0.84066 | 781 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 33 | 125 | 45 | L_Abluft | 0.84066 | 783 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Abluft | 1.61055 | 801 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 140 | 90 | L_Zuluft | 2.07281 | 698 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 140 | 90 | L_Zuluft | 2.07281 | 700 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 31 | 140 | 90 | L_Zuluft | 2.07281 | 744 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 31 | 140 | 90 | L_Zuluft | 2.07281 | 746 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Zuluft | 0.837588 | 536 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Abluft | 0.837588 | 576 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Zuluft | 0.837588 | 540 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Zuluft | 0.837588 | 542 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Abluft | 0.837588 | 578 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Abluft | 0.837588 | 582 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 125 | 90 | L_Zuluft | 1.61055 | 663 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 42 | 160 | 90 | L_Abluft | 1.71828 | 641 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 42 | 160 | 90 | L_Abluft | 1.71828 | 645 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 42 | 160 | 90 | L_Abluft | 1.71828 | 647 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 160 | 90 | L_Abluft | 1.71828 | 662 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 160 | 90 | L_Abluft | 1.71828 | 666 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 160 | 90 | L_Abluft | 1.71828 | 668 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 100 | 90 | L_Abluft | 1.48905 | 513 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 100 | 90 | L_Abluft | 1.48905 | 515 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 100 | 90 | L_Abluft | 1.48905 | 517 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 100 | 90 | L_Abluft | 1.48905 | 519 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Zuluft | 1.48905 | 464 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Zuluft | 1.48905 | 466 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Abluft | 0.837588 | 538 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Abluft | 0.837588 | 540 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 90 | L_Zuluft | 0.837588 | 518 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 90 | L_Zuluft | 0.837588 | 520 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 100 | 90 | L_Abluft | 0.837588 | 558 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 100 | 90 | L_Abluft | 0.837588 | 560 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 90 | L_Zuluft | 0.837588 | 522 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 125 | 90 | L_Zuluft | 1.61055 | 660 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 125 | 90 | L_Zuluft | 1.61055 | 656 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 140 | 90 | L_Zuluft | 2.42257 | 675 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Zuluft | 1.15312 | 723 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 31 | 140 | 90 | L_Zuluft | 2.07281 | 739 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 30 | 125 | 90 | L_Zuluft | 1.61055 | 756 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 30 | 125 | 90 | L_Zuluft | 1.61055 | 754 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 39 | 160 | 90 | L_Zuluft | 1.71828 | 608 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 160 | 90 | L_Zuluft | 1.71828 | 585 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 33 | 125 | 90 | L_Abluft | 1.15312 | 777 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Abluft | 1.61055 | 793 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 125 | 90 | L_Abluft | 1.61055 | 795 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 140 | 90 | L_Abluft | 2.07281 | 765 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 140 | 90 | L_Abluft | 2.07281 | 741 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 140 | 90 | L_Abluft | 2.42257 | 728 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 125 | 90 | L_Abluft | 1.61055 | 711 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 160 | 90 | L_Abluft | 1.71828 | 658 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 42 | 160 | 90 | L_Abluft | 1.71828 | 637 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Abluft | 0.837588 | 528 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 125 | 90 | L_Abluft | 1.86786 | 628 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 125 | 90 | L_Abluft | 1.86786 | 630 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 42 | 125 | 90 | L_Zuluft | 1.86786 | 577 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 42 | 125 | 90 | L_Zuluft | 1.86786 | 573 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 125 | 90 | L_Abluft | 1.86786 | 623 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 100 | 90 | L_Zuluft | 2.81523 | 618 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 40 | 100 | 90 | L_Abluft | 2.81523 | 675 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 39 | 160 | 90 | L_Abluft | 1.71828 | 695 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 39 | 160 | 90 | L_Abluft | 1.71828 | 693 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 160 | 90 | L_Zuluft | 1.71828 | 638 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 160 | 90 | L_Zuluft | 1.71828 | 640 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 160 | 90 | L_Zuluft | 1.71828 | 636 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 39 | 160 | 90 | L_Abluft | 1.71828 | 691 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 100 | 90 | L_Abluft | 2.81523 | 872 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 100 | 90 | L_Abluft | 2.81523 | 874 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 90 | L_Zuluft | 1.61055 | 864 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 90 | L_Zuluft | 1.61055 | 867 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 90 | L_Abluft | 1.61055 | 906 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 140 | 90 | L_Zuluft | 2.67088 | 820 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 140 | 90 | L_Abluft | 2.67088 | 855 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 140 | 90 | L_Abluft | 1.96228 | 888 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 140 | 90 | L_Abluft | 1.96228 | 892 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 140 | 90 | L_Abluft | 1.96228 | 894 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 125 | 90 | L_Abluft | 1.86786 | 143 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 125 | 90 | L_Abluft | 1.86786 | 146 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 125 | 90 | L_Abluft | 1.86786 | 148 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 65 | 125 | 90 | L_Zuluft | 1.86786 | 337 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 100 | 90 | L_Abluft | 0.372262 | 162 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 100 | 90 | L_Abluft | 0.372262 | 160 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 100 | 90 | L_Abluft | 0.372262 | 164 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 100 | 90 | L_Abluft | 0.372262 | 158 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 63 | 100 | 90 | L_Zuluft | 0.372262 | 350 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 63 | 100 | 90 | L_Zuluft | 0.372262 | 352 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 100 | 90 | L_Abluft | 1.14005 | 131 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 100 | 90 | L_Abluft | 1.14005 | 133 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 100 | 90 | L_Abluft | 1.88457 | 110 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 100 | 90 | L_Abluft | 1.88457 | 106 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 100 | 90 | L_Abluft | 1.14005 | 129 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 100 | 90 | L_Abluft | 1.88457 | 112 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 100 | 90 | L_Abluft | 1.88457 | 114 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 100 | 90 | L_Abluft | 1.88457 | 116 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 68 | 100 | 90 | L_Zuluft | 1.88457 | 304 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 68 | 100 | 90 | L_Zuluft | 1.88457 | 302 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 68 | 100 | 90 | L_Zuluft | 1.88457 | 306 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 68 | 100 | 90 | L_Zuluft | 1.88457 | 308 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 68 | 100 | 90 | L_Zuluft | 1.88457 | 310 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 67 | 100 | 90 | L_Zuluft | 1.14005 | 325 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 67 | 100 | 90 | L_Zuluft | 1.14005 | 327 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 67 | 100 | 90 | L_Zuluft | 1.14005 | 329 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 67 | 100 | 45 | L_Zuluft | 0.831134 | 322 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 67 | 100 | 45 | L_Zuluft | 0.831134 | 320 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 89 | 125 | 90 | L_Abluft | 2.43965 | 102 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 67 | 100 | 90 | L_Zuluft | 1.14005 | 316 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 89 | 125 | 90 | L_Abluft | 2.43965 | 100 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 125 | 90 | L_Abluft | 1.86786 | 139 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 80 | 125 | 90 | L_Abluft | 1.3723 | 221 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 80 | 125 | 90 | L_Abluft | 1.3723 | 224 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 89 | 125 | 90 | L_Zuluft | 1.3723 | 96 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 78 | 140 | 90 | L_Abluft | 1.75031 | 253 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 140 | 90 | L_Zuluft | 1.75031 | 127 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 140 | 90 | L_Zuluft | 1.75031 | 129 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 78 | 140 | 90 | L_Abluft | 1.75031 | 255 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 75 | 160 | 90 | L_Abluft | 2.58807 | 301 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 84 | 160 | 90 | L_Zuluft | 2.58807 | 175 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 73 | 125 | 90 | L_Abluft | 1.86786 | 332 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 73 | 125 | 90 | L_Abluft | 1.86786 | 335 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 125 | 90 | L_Zuluft | 1.86786 | 191 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 125 | 90 | L_Zuluft | 1.86786 | 194 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 76 | 180 | 90 | L_Abluft | 1.99471 | 290 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB | 85 | 180 | 90 | L_Zuluft | 1.99471 | 164 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 82 | 160 | 90 | L_Zuluft | 2.21885 | 205 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 82 | 160 | 90 | L_Zuluft | 2.21885 | 209 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 74 | 160 | 90 | L_Abluft | 2.21885 | 317 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 74 | 160 | 90 | L_Abluft | 2.21885 | 321 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 81 | 200 | 90 | L_Zuluft | 2.81523 | 225 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 81 | 200 | 90 | L_Zuluft | 2.81523 | 223 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 200 | 90 | L_Zuluft | 2.75161 | 253 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 200 | 90 | L_Zuluft | 2.75161 | 257 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 70 | 200 | 90 | L_Abluft | 2.75161 | 379 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 72 | 200 | 90 | L_Abluft | 2.81523 | 349 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 72 | 200 | 90 | L_Abluft | 2.81523 | 352 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 80 | 200 | 90 | L_Zuluft | 2.75161 | 239 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 80 | 200 | 90 | L_Zuluft | 2.75161 | 242 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 71 | 200 | 90 | L_Abluft | 2.75161 | 366 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 80 | 200 | 90 | L_Zuluft | 2.75161 | 235 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 71 | 200 | 90 | L_Abluft | 2.75161 | 362 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 70 | 200 | 90 | L_Abluft | 2.75161 | 373 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 70 | 200 | 90 | L_Abluft | 2.75161 | 375 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 200 | 90 | L_Zuluft | 2.75161 | 247 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 200 | 90 | L_Zuluft | 2.75161 | 249 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 81 | 200 | 90 | L_Zuluft | 2.81523 | 219 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 72 | 200 | 90 | L_Abluft | 2.81523 | 345 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 73 | 125 | 90 | L_Abluft | 1.86786 | 328 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 74 | 160 | 90 | L_Abluft | 2.21885 | 313 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 82 | 160 | 90 | L_Zuluft | 2.21885 | 201 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 125 | 90 | L_Zuluft | 1.86786 | 187 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 75 | 160 | 90 | L_Abluft | 2.58807 | 297 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 84 | 160 | 90 | L_Zuluft | 2.58807 | 171 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 85 | 180 | 90 | L_Zuluft | 1.99471 | 156 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 76 | 180 | 90 | L_Abluft | 1.99471 | 282 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 86 | 140 | 90 | L_Zuluft | 2.42257 | 140 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 86 | 140 | 90 | L_Zuluft | 2.42257 | 143 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 77 | 140 | 90 | L_Abluft | 2.42257 | 266 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 77 | 140 | 90 | L_Abluft | 2.42257 | 269 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 87 | 140 | 90 | L_Zuluft | 1.75031 | 123 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 78 | 140 | 90 | L_Abluft | 1.75031 | 249 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 86 | 140 | 90 | L_Zuluft | 2.42257 | 136 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 77 | 140 | 90 | L_Abluft | 2.42257 | 262 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 140 | 90 | L_Zuluft | 1.96228 | 109 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 140 | 90 | L_Zuluft | 1.96228 | 112 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 140 | 90 | L_Abluft | 1.96228 | 235 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 140 | 90 | L_Abluft | 1.96228 | 238 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 89 | 125 | 90 | L_Zuluft | 1.3723 | 92 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 80 | 125 | 90 | L_Abluft | 1.3723 | 217 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 79 | 140 | 90 | L_Abluft | 1.96228 | 231 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 89 | 125 | 90 | L_Zuluft | 1.3723 | 98 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 69 | 160 | 90 | L_Zuluft | 1.96058 | 281 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 93 | 160 | 90 | L_Abluft | 1.96058 | 73 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 70 | 160 | 90 | L_Zuluft | 1.96058 | 270 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Abluft | 1.96058 | 84 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 88 | 140 | 90 | L_Zuluft | 1.96228 | 105 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 160 | 90 | L_Zuluft | 1.96058 | 61 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 160 | 90 | L_Zuluft | 1.96058 | 64 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 160 | 90 | L_Abluft | 1.96058 | 175 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 160 | 90 | L_Abluft | 1.96058 | 178 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 125 | 45 | L_Zuluft | 1.77859 | 79 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 125 | 45 | L_Zuluft | 1.77859 | 77 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 125 | 90 | L_Zuluft | 2.43965 | 73 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 81 | 125 | 90 | L_Abluft | 2.43965 | 200 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 125 | 90 | L_Zuluft | 2.43965 | 71 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 81 | 125 | 90 | L_Abluft | 2.43965 | 204 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 81 | 125 | 90 | L_Abluft | 2.43965 | 207 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 91 | 160 | 90 | L_Zuluft | 1.96058 | 57 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Zuluft | 1.96058 | 44 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 82 | 160 | 90 | L_Abluft | 1.96058 | 186 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 160 | 90 | L_Abluft | 1.96058 | 171 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Abluft | 1.96058 | 80 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 69 | 160 | 90 | L_Zuluft | 1.96058 | 283 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Abluft | 1.96058 | 86 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 69 | 160 | 90 | L_Zuluft | 1.96058 | 277 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 70 | 160 | 90 | L_Zuluft | 1.96058 | 266 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 93 | 160 | 90 | L_Abluft | 1.96058 | 75 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 93 | 160 | 90 | L_Abluft | 1.96058 | 69 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 140 | 90 | L_Zuluft | 0.732827 | 845 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 45 | L_Zuluft | 1.17414 | 858 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 100 | 90 | L_Zuluft | 2.81523 | 829 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 140 | 90 | L_Abluft | 1.96228 | 884 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 140 | 90 | L_Abluft | 2.67088 | 849 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 200 | 90 | L_Abluft | 2.75161 | 828 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 200 | 90 | L_Abluft | 2.75161 | 830 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 58 | 200 | 90 | L_Abluft | 2.75161 | 434 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 57 | 200 | 90 | L_Zuluft | 2.75161 | 403 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 57 | 200 | 90 | L_Zuluft | 2.75161 | 405 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 200 | 90 | L_Zuluft | 2.75161 | 413 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 200 | 90 | L_Zuluft | 2.75161 | 415 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 33 | 125 | 90 | L_Zuluft | 0.238247 | 711 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 33 | 125 | 90 | L_Zuluft | 0.238247 | 709 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 125 | 90 | L_Abluft | 0.238247 | 755 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 125 | 90 | L_Abluft | 0.238247 | 753 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 140 | 90 | L_Zuluft | 2.07281 | 693 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 40 | 125 | 90 | L_Zuluft | 1.26033 | 598 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 54 | 100 | 90 | L_Abluft | 1.68099 | 497 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 90 | L_Abluft | 1.68099 | 592 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 125 | 90 | L_Zuluft | 1.26033 | 475 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 140 | 90 | L_Abluft | 2.30295 | 530 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 140 | 90 | L_Abluft | 2.30295 | 528 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 140 | 90 | L_Abluft | 2.18637 | 546 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 140 | 90 | L_Abluft | 2.18637 | 497 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 140 | 90 | L_Abluft | 2.18637 | 495 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 140 | 90 | L_Abluft | 2.18637 | 478 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 140 | 90 | L_Zuluft | 2.18637 | 499 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 140 | 90 | L_Zuluft | 2.18637 | 497 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 20 | 140 | 90 | L_Zuluft | 2.18637 | 444 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 140 | 90 | L_Abluft | 2.18637 | 439 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 140 | 90 | L_Zuluft | 2.18637 | 459 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 140 | 90 | L_Zuluft | 2.18637 | 457 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 140 | 90 | L_Zuluft | 2.18637 | 470 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 140 | 90 | L_Abluft | 2.18637 | 437 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Abluft | 2.18637 | 451 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Abluft | 2.18637 | 454 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Abluft | 2.18637 | 459 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 140 | 90 | L_Zuluft | 2.18637 | 473 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 30 | 200 | 90 | L_Abluft | 2.32663 | 417 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 21 | 200 | 90 | L_Zuluft | 2.32663 | 415 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Bogen | EG_Verwaltung_FFB |  | 125 | 90 | L_Zuluft | 1.61055 |  | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x Bogen | EG_Verwaltung_FFB |  | 125 | 90 | L_Zuluft | 2.75414 |  | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 90 | L_Abluft | 2.75414 | 616 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 125 | 90 | L_Abluft | 2.75414 | 596 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 90 | L_Abluft | 2.75414 | 609 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 90 | L_Abluft | 2.75414 | 611 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 125 | 90 | L_Abluft | 2.75414 | 601 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 125 | 90 | L_Abluft | 1.61055 | 585 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 125 | 90 | L_Abluft | 1.61055 | 587 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 125 | 90 | L_Abluft | 1.61055 | 582 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 125 | 90 | L_Abluft | 1.61055 | 578 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 125 | 90 | L_Zuluft | 1.3723 | 373 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 90 | L_Abluft | 1.3723 | 351 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 90 | L_Abluft | 1.3723 | 354 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 90 | L_Abluft | 1.3723 | 356 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.372262 | 239 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.372262 | 241 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.372262 | 243 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 100 | 90 | L_Zuluft | 0.372262 | 262 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 100 | 90 | L_Zuluft | 0.372262 | 264 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 46 | 100 | 90 | L_Abluft | 0.372262 | 272 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 46 | 100 | 90 | L_Abluft | 0.372262 | 274 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 100 | 90 | L_Zuluft | 0.372262 | 295 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 100 | 90 | L_Zuluft | 0.372262 | 297 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 46 | 100 | 90 | L_Abluft | 0.372262 | 276 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 45 | 100 | 90 | L_Abluft | 0.837588 | 288 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 45 | 100 | 90 | L_Abluft | 0.837588 | 290 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 100 | 90 | L_Zuluft | 0.837588 | 279 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 100 | 90 | L_Zuluft | 0.837588 | 281 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Abluft | 2.81523 | 49 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 200 | 90 | L_Abluft | 2.81523 | 63 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 200 | 90 | L_Abluft | 2.81523 | 74 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Zuluft | 2.81523 | 19 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Zuluft | 2.81523 | 21 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Zuluft | 2.81523 | 14 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 200 | 90 | L_Zuluft | 2.81523 | 27 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 200 | 90 | L_Zuluft | 2.81523 | 43 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 200 | 90 | L_Zuluft | 2.81523 | 57 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 200 | 90 | L_Zuluft | 2.81523 | 72 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 200 | 90 | L_Zuluft | 2.81523 | 98 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 200 | 90 | L_Zuluft | 2.81523 | 87 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 200 | 90 | L_Zuluft | 2.81523 | 108 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 200 | 90 | L_Zuluft | 2.81523 | 110 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 200 | 90 | L_Abluft | 2.81523 | 94 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 200 | 90 | L_Abluft | 2.81523 | 104 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 200 | 90 | L_Abluft | 2.81523 | 120 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 200 | 90 | L_Abluft | 2.81523 | 144 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 200 | 90 | L_Abluft | 2.81523 | 146 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 200 | 90 | L_Abluft | 2.81523 | 135 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 160 | 90 | L_Abluft | 2.78333 | 239 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 160 | 90 | L_Zuluft | 1.71828 | 282 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 125 | 90 | L_Abluft | 1.61055 | 228 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 125 | 90 | L_Zuluft | 1.61055 | 270 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 180 | 90 | L_Abluft | 3.72568 | 224 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 180 | 90 | L_Zuluft | 2.71503 | 266 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 125 | 90 | L_Zuluft | 1.15312 | 257 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 125 | 90 | L_Zuluft | 1.15312 | 259 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 125 | 90 | L_Zuluft | 1.15312 | 252 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 17 | 125 | 90 | L_Abluft | 1.15312 | 213 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Abluft | 2.43965 | 175 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 125 | 90 | L_Zuluft | 2.43965 | 212 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 20 | 125 | 90 | L_Abluft | 2.43965 | 165 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Zuluft | 2.43965 | 202 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 125 | 90 | L_Zuluft | 2.43965 | 214 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Abluft | 2.43965 | 177 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 125 | 90 | L_Zuluft | 2.43965 | 220 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 125 | 90 | L_Zuluft | 2.43965 | 223 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Abluft | 2.43965 | 183 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Abluft | 2.43965 | 186 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 17 | 180 | 90 | L_Zuluft | 2.26954 | 190 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 180 | 90 | L_Abluft | 2.26954 | 153 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 100 | 90 | L_Abluft | 0.837588 | 250 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 100 | 90 | L_Abluft | 0.837588 | 252 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 160 | 90 | L_Abluft | 2.78333 | 241 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 160 | 90 | L_Abluft | 2.78333 | 243 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 125 | 90 | L_Abluft | 4.61247 | 262 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 160 | 90 | L_Zuluft | 1.71828 | 284 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 160 | 90 | L_Zuluft | 1.71828 | 286 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 180 | 90 | L_Zuluft | 2.19917 | 364 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 180 | 90 | L_Zuluft | 2.19917 | 366 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 180 | 90 | L_Abluft | 2.19917 | 354 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 180 | 90 | L_Abluft | 2.19917 | 356 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 100 | 90 | L_Zuluft | 0.837588 | 333 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Zuluft | 0.837588 | 348 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 100 | 90 | L_Zuluft | 0.837588 | 335 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 100 | 90 | L_Zuluft | 0.837588 | 337 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Abluft | 0.837588 | 311 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Zuluft | 0.837588 | 350 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Zuluft | 0.837588 | 352 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Abluft | 0.837588 | 313 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Abluft | 0.837588 | 315 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 90 | L_Abluft | 0.837588 | 317 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 100 | 90 | L_Abluft | 0.837588 | 330 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 100 | 90 | L_Abluft | 0.837588 | 332 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 100 | 90 | L_Abluft | 0.837588 | 327 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 100 | 90 | L_Abluft | 0.837588 | 334 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 100 | 90 | L_Abluft | 1.88457 | 92 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 160 | 90 | L_Zuluft | 1.87804 | 146 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 160 | 90 | L_Abluft | 1.87804 | 84 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 100 | 90 | L_Zuluft | 1.88457 | 154 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 100 | 90 | L_Zuluft | 1.88457 | 156 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
