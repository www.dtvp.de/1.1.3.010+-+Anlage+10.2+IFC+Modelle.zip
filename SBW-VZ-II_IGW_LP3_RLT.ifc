Properties of the parts of a building model (IFC2X3), part 17 of 18

# IfcFlowTerminal: DTQ0 - 400 - 400 - K1 - 200 (119)
Name | Section No | Tech-Medium | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No.
DTQ0 - 400 - 400 - K1 - 200 | 82 | L_Zuluft | 47.7222 | 250 | 213
DTQ0 - 400 - 400 - K1 - 200 | 74 | L_Abluft | 60.8736 | 250 | 325
DTQ0 - 400 - 400 - K1 - 200 | 70 | L_Abluft | 56.4069 | 435 | 384
DTQ0 - 400 - 400 - K1 - 200 | 72 | L_Abluft | 51.3515 | 440 | 354
DTQ0 - 400 - 400 - K1 - 200 | 71 | L_Abluft | 51.2162 | 435 | 370
DTQ0 - 400 - 400 - K1 - 200 | 80 | L_Zuluft | 33.5276 | 435 | 244
DTQ0 - 400 - 400 - K1 - 200 | 79 | L_Zuluft | 39.503 | 435 | 259
DTQ0 - 400 - 400 - K1 - 200 | 81 | L_Zuluft | 37.1208 | 440 | 227
DTQ0 - 400 - 400 - K1 - 200 | 30 | L_Abluft | 139.959 | 400 | 423
DTQ0 - 400 - 400 - K1 - 200 | 21 | L_Zuluft | 158.135 | 400 | 421
DTQ0 - 400 - 400 - K1 - 200 | 32 | L_Abluft | 158.863 | 320 | 387
DTQ0 - 400 - 400 - K1 - 200 | 23 | L_Zuluft | 168.661 | 320 | 392
DTQ0 - 400 - 400 - K1 - 200 | 39 | L_Zuluft | 79.293 | 210 | 249
DTQ0 - 400 - 400 - K1 - 200 | 47 | L_Abluft | 56.2787 | 210 | 259
DTQ0 - 400 - 400 - K1 - 200 | 7 | L_Abluft | 156.974 | 450 | 633
DTQ0 - 400 - 400 - K1 - 200 | 41 | L_Zuluft | 161.251 | 450 | 196
DTQ0 - 400 - 400 - K1 - 200 |  | L_Zuluft | 132.473 | 170
DTQ0 - 400 - 400 - K1 - 200 |  | L_Zuluft | 133.748 | 170
DTQ0 - 400 - 400 - K1 - 200 | 10 | L_Abluft | 145.76 | 170 | 620
DTQ0 - 400 - 400 - K1 - 200 | 11 | L_Abluft | 144.973 | 170 | 605
DTQ0 - 400 - 400 - K1 - 200 | 40 | L_Zuluft | 144.56 | 210 | 220
DTQ0 - 400 - 400 - K1 - 200 | 34 | L_Abluft | 143.966 | 210 | 368
DTQ0 - 400 - 400 - K1 - 200 | 28 | L_Zuluft | 126.088 | 210 | 354
DTQ0 - 400 - 400 - K1 - 200 | 49 | L_Abluft | 122.886 | 210 | 219
DTQ0 - 400 - 400 - K1 - 200 | 14 | L_Zuluft | 101.745 | 195 | 536
DTQ0 - 400 - 400 - K1 - 200 | 24 | L_Abluft | 93.5056 | 195 | 537
DTQ0 - 400 - 400 - K1 - 200 | 13 | L_Zuluft | 90.6888 | 190 | 552
DTQ0 - 400 - 400 - K1 - 200 | 23 | L_Abluft | 82.1485 | 190 | 553
DTQ0 - 400 - 400 - K1 - 200 | 12 | L_Zuluft | 80.1517 | 195 | 563
DTQ0 - 400 - 400 - K1 - 200 | 22 | L_Abluft | 69.3589 | 195 | 568
DTQ0 - 400 - 400 - K1 - 200 | 25 | L_Abluft | 113.074 | 190 | 504
DTQ0 - 400 - 400 - K1 - 200 | 26 | L_Abluft | 119.332 | 190 | 485
DTQ0 - 400 - 400 - K1 - 200 | 15 | L_Zuluft | 120.768 | 190 | 506
DTQ0 - 400 - 400 - K1 - 200 | 20 | L_Zuluft | 127.064 | 190 | 451
DTQ0 - 400 - 400 - K1 - 200 | 19 | L_Zuluft | 120.388 | 190 | 466
DTQ0 - 400 - 400 - K1 - 200 | 18 | L_Zuluft | 91.5417 | 190 | 489
DTQ0 - 400 - 400 - K1 - 200 | 29 | L_Abluft | 119.204 | 190 | 446
DTQ0 - 400 - 400 - K1 - 200 | 28 | L_Abluft | 85.8957 | 190 | 470
DTQ0 - 400 - 400 - K1 - 200 | 15 | L_Abluft | 9.48011 | 440 | 70
DTQ0 - 400 - 400 - K1 - 200 | 16 | L_Abluft | 20.3532 | 440 | 55
DTQ0 - 400 - 400 - K1 - 200 | 14 | L_Abluft | 23.0684 | 440 | 80
DTQ0 - 400 - 400 - K1 - 200 | 13 | L_Abluft | 7.06024 | 440 | 101
DTQ0 - 400 - 400 - K1 - 200 | 12 | L_Abluft | 15.4845 | 440 | 110
DTQ0 - 400 - 400 - K1 - 200 | 11 | L_Abluft | 8.88485 | 440 | 126
DTQ0 - 400 - 400 - K1 - 200 | 10 | L_Abluft | 0 | 440 | 142
DTQ0 - 400 - 400 - K1 - 200 | 9 | L_Abluft | 15.3761 | 440 | 152
DTQ0 - 400 - 400 - K1 - 200 | 15 | L_Zuluft | 5.28728 | 440 | 35
DTQ0 - 400 - 400 - K1 - 200 | 14 | L_Zuluft | 12.2253 | 440 | 49
DTQ0 - 400 - 400 - K1 - 200 | 16 | L_Zuluft | 12.375 | 440 | 23
DTQ0 - 400 - 400 - K1 - 200 | 13 | L_Zuluft | 13.1898 | 440 | 63
DTQ0 - 400 - 400 - K1 - 200 | 12 | L_Zuluft | 11.2219 | 440 | 78
DTQ0 - 400 - 400 - K1 - 200 | 10 | L_Zuluft | 6.66435 | 440 | 104
DTQ0 - 400 - 400 - K1 - 200 | 9 | L_Zuluft | 7.40027 | 440 | 116
DTQ0 - 400 - 400 - K1 - 200 | 11 | L_Zuluft | 0 | 440 | 94
DTQ0 - 400 - 400 - K1 - 200 | 8 | L_Abluft | 13.2931 | 315 | 348
DTQ0 - 400 - 400 - K1 - 200 | 8 | L_Zuluft | 30.8873 | 315 | 378
DTQ0 - 400 - 400 - K1 - 200 | 9 | L_Zuluft | 29.0944 | 315 | 370
DTQ0 - 400 - 400 - K1 - 200 | 7 | L_Abluft | 11.475 | 315 | 360
DTQ0 - 400 - 400 - K1 - 200 | 28 | L_Zuluft | 44.1352 | 220 | 106
DTQ0 - 400 - 400 - K1 - 200 | 22 | L_Abluft | 46.0159 | 220 | 143
DTQ0 - 400 - 400 - K1 - 200 | 27 | L_Zuluft | 33.1819 | 275 | 122
DTQ0 - 400 - 400 - K1 - 200 | 26 | L_Zuluft | 24.4685 | 275 | 142
DTQ0 - 400 - 400 - K1 - 200 | 29 | L_Abluft | 32.4127 | 275 | 67
DTQ0 - 400 - 400 - K1 - 200 | 28 | L_Abluft | 28.7556 | 275 | 81
DTQ0 - 400 - 400 - K1 - 200 | 10 | L_Zuluft | 23.9196 | 240 | 216
DTQ0 - 400 - 400 - K1 - 200 | 11 | L_Abluft | 18.9737 | 240 | 272
DTQ0 - 400 - 400 - K1 - 200 | 12 | L_Abluft | 13.6618 | 250 | 260
DTQ0 - 400 - 400 - K1 - 200 | 14 | L_Abluft | 15.9049 | 250 | 223
DTQ0 - 400 - 400 - K1 - 200 | 7 | L_Abluft | 26.7948 | 250 | 288
DTQ0 - 400 - 400 - K1 - 200 | 6 | L_Abluft | 31.9514 | 250 | 304
DTQ0 - 400 - 400 - K1 - 200 | 11 | L_Zuluft | 7.90947 | 250 | 205
DTQ0 - 400 - 400 - K1 - 200 | 12 | L_Zuluft | 10.5066 | 250 | 194
DTQ0 - 400 - 400 - K1 - 200 | 19 | L_Zuluft | 16.7484 | 245 | 146
DTQ0 - 400 - 400 - K1 - 200 | 20 | L_Zuluft | 0.723826 | 245 | 136
DTQ0 - 400 - 400 - K1 - 200 | 21 | L_Zuluft | 15.0062 | 245 | 120
DTQ0 - 400 - 400 - K1 - 200 | 27 | L_Zuluft | 25.4617 | 245 | 44
DTQ0 - 400 - 400 - K1 - 200 | 22 | L_Zuluft | 20.8618 | 245 | 103
DTQ0 - 400 - 400 - K1 - 200 | 23 | L_Zuluft | 12.9614 | 245 | 92
DTQ0 - 400 - 400 - K1 - 200 | 26 | L_Zuluft | 9.96177 | 245 | 62
DTQ0 - 400 - 400 - K1 - 200 | 25 | L_Zuluft | 13.5274 | 245 | 74
DTQ0 - 400 - 400 - K1 - 200 | 26 | L_Abluft | 9.04559 | 245 | 124
DTQ0 - 400 - 400 - K1 - 200 | 27 | L_Abluft | 6.25565 | 245 | 112
DTQ0 - 400 - 400 - K1 - 200 | 28 | L_Abluft | 23.6979 | 245 | 90
DTQ0 - 400 - 400 - K1 - 200 | 24 | L_Abluft | 14.777 | 245 | 141
DTQ0 - 400 - 400 - K1 - 200 | 23 | L_Abluft | 15.2439 | 245 | 155
DTQ0 - 400 - 400 - K1 - 200 | 22 | L_Abluft | 22.4289 | 245 | 165
DTQ0 - 400 - 400 - K1 - 200 | 20 | L_Abluft | 15.9061 | 245 | 198
DTQ0 - 400 - 400 - K1 - 200 | 21 | L_Abluft | 4.38775 | 245 | 189
DTQ0 - 400 - 400 - K1 - 200 | 6 | L_Zuluft | 24.4586 | 250 | 232
DTQ0 - 400 - 400 - K1 - 200 | 5 | L_Zuluft | 27.3012 | 250 | 252

# IfcFlowTerminal: Luftauslass RLT-Decke Abluft (12)
In: EG_Verwaltung_FFB
Description: Luftauslass RLT-Decke Abluft
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Luftauslass RLT-Decke Abluft

# IfcFlowTerminal: Luftauslass RLT-Decke Zuluft (47)
In: EG_Verwaltung_FFB
Description: Luftauslass RLT-Decke Zuluft
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Luftauslass RLT-Decke Zuluft

# IfcFlowTerminal: Lüftungsdecke (83)
In: EG_Verwaltung_FFB
Description: Lüftungsdecke
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Lüftungsdecke; Info: ca. 30 kg/m²; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Lüftungsdecke - nur Berechnung (133)
In: EG_Verwaltung_FFB
Description: Lüftungsdecke - nur Berechnung
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Calc-Pressure loss (Pa): 15 Pa; Name: Lüftungsdecke - nur Berechnung; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Connection diameter (mm) (mm) | Geom-Head diameter (mm) (mm) | Tech-Medium | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No.
Lüftungsdecke - nur Berechnung | 183 | 200 | 200 | L_Zuluft | 16.1533 | 394 | 390
Lüftungsdecke - nur Berechnung | 10 | 325 | 345 | L_Abluft | 0 | 895 | 508
Lüftungsdecke - nur Berechnung | 14 | 325 | 345 | L_Abluft | 33.8895 | 896 | 494
Lüftungsdecke - nur Berechnung | 200 | 200 | 200 | L_Zuluft | 5.36529 | 394 | 340
Lüftungsdecke - nur Berechnung | 195 | 200 | 200 | L_Zuluft | 5.44668 | 394 | 353
Lüftungsdecke - nur Berechnung | 7 | 325 | 345 | L_Abluft | 45.0617 | 432 | 525
Lüftungsdecke - nur Berechnung | 199 | 200 | 200 | L_Zuluft | 12.5838 | 394 | 344
Lüftungsdecke - nur Berechnung | 176 | 200 | 200 | L_Zuluft | 16.1464 | 295 | 411
Lüftungsdecke - nur Berechnung | 184 | 200 | 200 | L_Zuluft | 15.3696 | 394 | 386
Lüftungsdecke - nur Berechnung | 11 | 325 | 345 | L_Abluft | 0 | 895 | 502
Lüftungsdecke - nur Berechnung | 186 | 200 | 200 | L_Zuluft | 7.34331 | 394 | 379
Lüftungsdecke - nur Berechnung | 9 | 325 | 345 | L_Abluft | 31.2345 | 516 | 518
Lüftungsdecke - nur Berechnung | 187 | 200 | 200 | L_Zuluft | 6.53363 | 394 | 375
Lüftungsdecke - nur Berechnung | 196 | 200 | 200 | L_Zuluft | 9.42762 | 394 | 348
Lüftungsdecke - nur Berechnung | 201 | 200 | 200 | L_Zuluft | 9.41135 | 394 | 335
Lüftungsdecke - nur Berechnung | 177 | 200 | 200 | L_Zuluft | 15.4431 | 295 | 407
Lüftungsdecke - nur Berechnung | 16 | 325 | 345 | L_Abluft | 47.1699 | 431 | 481
Lüftungsdecke - nur Berechnung | 15 | 325 | 345 | L_Abluft | 3.7661 | 896 | 489
Lüftungsdecke - nur Berechnung | 194 | 200 | 200 | L_Zuluft | 12.5273 | 394 | 357
Lüftungsdecke - nur Berechnung | 188 | 200 | 200 | L_Zuluft | 65.0426 | 361 | 58
Lüftungsdecke - nur Berechnung | 191 | 200 | 200 | L_Zuluft | 67.9067 | 360 | 45
Lüftungsdecke - nur Berechnung | 171 | 200 | 200 | L_Zuluft | 64.737 | 361 | 103
Lüftungsdecke - nur Berechnung | 187 | 200 | 200 | L_Zuluft | 65.0861 | 360 | 61
Lüftungsdecke - nur Berechnung | 189 | 200 | 200 | L_Zuluft | 67.0862 | 360 | 53
Lüftungsdecke - nur Berechnung | 172 | 200 | 200 | L_Zuluft | 64.8238 | 360 | 100
Lüftungsdecke - nur Berechnung | 192 | 200 | 200 | L_Zuluft | 67.9805 | 361 | 40
Lüftungsdecke - nur Berechnung | 169 | 200 | 200 | L_Zuluft | 68.5271 | 361 | 112
Lüftungsdecke - nur Berechnung | 175 | 200 | 200 | L_Zuluft | 67.4565 | 361 | 86
Lüftungsdecke - nur Berechnung | 190 | 200 | 200 | L_Zuluft | 67.0346 | 361 | 50
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 23.132 | 360 | 225
Lüftungsdecke - nur Berechnung | 173 | 200 | 200 | L_Zuluft | 66.7213 | 361 | 94
Lüftungsdecke - nur Berechnung | 174 | 200 | 200 | L_Zuluft | 66.817 | 360 | 91
Lüftungsdecke - nur Berechnung | 176 | 200 | 200 | L_Zuluft | 68.5568 | 360 | 83
Lüftungsdecke - nur Berechnung | 186 | 200 | 200 | L_Zuluft | 64.2344 | 361 | 67
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 23.9982 | 361 | 229
Lüftungsdecke - nur Berechnung | 170 | 200 | 200 | L_Zuluft | 64.0281 | 360 | 108
Lüftungsdecke - nur Berechnung | 185 | 200 | 200 | L_Zuluft | 70.2912 | 360 | 70
Lüftungsdecke - nur Berechnung | 14 | 200 | 200 | L_Zuluft | 50.8677 | 337 | 620
Lüftungsdecke - nur Berechnung | 65 | 325 | 345 | L_Abluft | 61.5446 | 900 | 172
Lüftungsdecke - nur Berechnung | 59 | 325 | 345 | L_Abluft | 56.8857 | 1350 | 210
Lüftungsdecke - nur Berechnung | 57 | 325 | 345 | L_Abluft | 54.376 | 1350 | 222
Lüftungsdecke - nur Berechnung | 68 | 325 | 345 | L_Abluft | 62.4943 | 900 | 154
Lüftungsdecke - nur Berechnung | 49 | 200 | 200 | L_Abluft | 67.5778 | 450 | 269
Lüftungsdecke - nur Berechnung | 56 | 325 | 345 | L_Abluft | 50.8111 | 1350 | 230
Lüftungsdecke - nur Berechnung | 39 | 325 | 345 | L_Abluft | 52.9413 | 1125 | 343
Lüftungsdecke - nur Berechnung | 23 | 200 | 200 | L_Zuluft | 55.0743 | 367 | 577
Lüftungsdecke - nur Berechnung | 67 | 325 | 345 | L_Abluft | 59.0545 | 900 | 161
Lüftungsdecke - nur Berechnung | 16 | 200 | 200 | L_Zuluft | 48.6998 | 337 | 612
Lüftungsdecke - nur Berechnung | 45 | 325 | 345 | L_Abluft | 58.8042 | 1100 | 306
Lüftungsdecke - nur Berechnung | 15 | 200 | 200 | L_Zuluft | 46.8436 | 338 | 617
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Zuluft | 61.0492 | 367 | 581
Lüftungsdecke - nur Berechnung | 31 | 200 | 200 | L_Zuluft | 48.5748 | 367 | 552
Lüftungsdecke - nur Berechnung | 41 | 325 | 345 | L_Abluft | 51.1031 | 1125 | 337
Lüftungsdecke - nur Berechnung | 60 | 325 | 345 | L_Abluft | 60.4771 | 1350 | 202
Lüftungsdecke - nur Berechnung | 76 | 325 | 345 | L_Abluft | 33.5776 | 1350 | 103
Lüftungsdecke - nur Berechnung | 17 | 200 | 200 | L_Zuluft | 48.5186 | 338 | 609
Lüftungsdecke - nur Berechnung | 27 | 200 | 200 | L_Zuluft | 53.8546 | 367 | 568
Lüftungsdecke - nur Berechnung | 26 | 200 | 200 | L_Zuluft | 59.8303 | 367 | 572
Lüftungsdecke - nur Berechnung | 42 | 325 | 345 | L_Abluft | 53.0067 | 1125 | 329
Lüftungsdecke - nur Berechnung | 46 | 325 | 345 | L_Abluft | 57.9085 | 1100 | 298
Lüftungsdecke - nur Berechnung | 64 | 325 | 345 | L_Abluft | 58.105 | 900 | 179
Lüftungsdecke - nur Berechnung | 38 | 325 | 345 | L_Abluft | 51.0376 | 1125 | 351
Lüftungsdecke - nur Berechnung | 75 | 325 | 345 | L_Abluft | 29.7333 | 1350 | 111
Lüftungsdecke - nur Berechnung | 32 | 200 | 200 | L_Zuluft | 42.5421 | 367 | 548
7 x Lüftungsdecke - nur Berechnung | 234 | 200 | 200 | L_Zuluft | 3.4889 | 290 | 208
7 x Lüftungsdecke - nur Berechnung | 231 | 200 | 200 | L_Zuluft | 6.30974 | 289 | 218
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 25.449 | 450 | 432
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 29.7762 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 23.1812 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 24.2634 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 24.3551 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 26.2389 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 26.3573 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 27.3136 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 27.4028 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 28.361 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 27.561 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 25.2921 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 25.3631 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 24.1361 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 29.9306 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 32.8932 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 32.9472 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 33.7779 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 32.9762 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 30.8788 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 30.9576 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 29.7297 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 35.4744 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 31.827 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 31.8949 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 29.8768 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 29.9384 | 360 | 452
Lüftungsdecke - nur Berechnung | 62 | 200 | 200 | L_Zuluft | 35.3192 | 361 | 455
Lüftungsdecke - nur Berechnung | 63 | 200 | 200 | L_Zuluft | 28.7004 | 360 | 452
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 22.7928 | 360 | 225
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 22.7267 | 361 | 229
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 20.8851 | 360 | 225
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 20.7781 | 361 | 229
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 25.5006 | 360 | 225
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 19.6391 | 361 | 229
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 48.2481 | 360 | 225
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 54.9277 | 361 | 229
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 49.5103 | 360 | 225
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 49.3647 | 361 | 229
Lüftungsdecke - nur Berechnung | 133 | 200 | 200 | L_Zuluft | 51.416 | 360 | 225
Lüftungsdecke - nur Berechnung | 132 | 200 | 200 | L_Zuluft | 51.402 | 361 | 229
Lüftungsdecke - nur Berechnung | 49 | 200 | 200 | L_Abluft | 50.3071 | 450 | 269
Lüftungsdecke - nur Berechnung | 49 | 200 | 200 | L_Abluft | 47.3295 | 450 | 269
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 24.529 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 35.5523 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 25.3565 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 30.0784 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 29.0406 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 40.3897 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 24.3556 | 450 | 432
Lüftungsdecke - nur Berechnung | 22 | 200 | 200 | L_Abluft | 35.5154 | 450 | 432
Lüftungsdecke - nur Berechnung | 57 | 325 | 345 | L_Abluft | 71.6804 | 1000 | 222
Lüftungsdecke - nur Berechnung | 56 | 325 | 345 | L_Abluft | 70.1957 | 1000 | 230
Lüftungsdecke - nur Berechnung | 76 | 325 | 345 | L_Abluft | 62.0664 | 1350 | 103
Lüftungsdecke - nur Berechnung | 75 | 325 | 345 | L_Abluft | 46.9739 | 1350 | 111

# IfcFlowTerminal: Lüftungsgitter Kanaleinbau (16)
In: Wartung_FFB
Description: Lüftungsgitter Kanaleinbau
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Side 1 (mm): 225 mm; Geom-Side 2 (mm): 1225 mm; Tech-Medium: L_Abluft; Calc-Pressure loss (Pa): 10 Pa; Calc-Volumetric flow (m3/h): 2050 m3/hour; Name: Lüftungsgitter Kanaleinbau; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Calc-Required throttling (Pa) (Pa) | Pos. No.
Lüftungsgitter Kanaleinbau | 9 | 5.00896 | 147
Lüftungsgitter Kanaleinbau | 10 | 5.00896 | 146
Lüftungsgitter Kanaleinbau | 11 | 5.00896 | 145
Lüftungsgitter Kanaleinbau | 12 | 5.00896 | 144
Lüftungsgitter Kanaleinbau | 15 | 0 | 126
Lüftungsgitter Kanaleinbau | 16 | 0 | 125
Lüftungsgitter Kanaleinbau | 17 | 0 | 124
Lüftungsgitter Kanaleinbau | 18 | 0 | 123
Lüftungsgitter Kanaleinbau | 21 | 17.1699 | 98
Lüftungsgitter Kanaleinbau | 22 | 17.1699 | 97
Lüftungsgitter Kanaleinbau | 23 | 17.1699 | 96
Lüftungsgitter Kanaleinbau | 24 | 17.1699 | 95
Lüftungsgitter Kanaleinbau | 27 | 13.2725 | 87
Lüftungsgitter Kanaleinbau | 28 | 13.2725 | 86
Lüftungsgitter Kanaleinbau | 29 | 13.2725 | 85
Lüftungsgitter Kanaleinbau | 30 | 13.2725 | 84

# IfcFlowTerminal: Quader (61)
In: EG_Verwaltung_FFB
Description: Quader
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Quader; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Quellluftauslass (53)
Description: Quellluftauslass
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Medium: L_Zuluft; Calc-Pressure loss (Pa): 0 Pa; Name: Quellluftauslass; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Section No | Pset_MEP, Geom-Connection diameter (mm) (mm) | Geom-Outer diameter (mm) (m) | Length (mm) (m) | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No. | Floor | Floor No.
Quellluftauslass | Wartung_FFB | 88 | 160 | 250 | 500 | 102.076 | 325 | 455 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 87 | 160 | 250 | 500 | 95.5054 | 325 | 468 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 86 | 160 | 250 | 500 | 87.7267 | 325 | 476 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 85 | 160 | 250 | 500 | 79.5843 | 325 | 485 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 50 | 160 | 250 | 500 | 31.5848 | 325 | 195 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 51 | 160 | 250 | 500 | 36.9357 | 325 | 186 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 52 | 160 | 250 | 500 | 43.3638 | 325 | 178 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 53 | 160 | 250 | 500 | 48.3408 | 325 | 167 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 91 |  | 830 | 2000 | 202.063 | 4300 | 426 | Wartung_FFB | 2 | Pset_MEP - Geom-Connection diameter (mm): 630 m
Quellluftauslass | Wartung_FFB | 143 | 160 | 250 | 500 | 116.409 | 325 | 104 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 142 | 160 | 250 | 500 | 113.299 | 325 | 118 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 133 |  | 830 | 2000 | 144.93 | 4300 | 199 | Wartung_FFB | 2 | Pset_MEP - Geom-Connection diameter (mm): 630 m
Quellluftauslass | Wartung_FFB | 56 |  | 830 | 2000 | 147.426 | 4300 | 139 | Wartung_FFB | 2 | Pset_MEP - Geom-Connection diameter (mm): 630 m
Quellluftauslass | Wartung_FFB | 31 |  | 830 | 2000 | 149.245 | 4300 | 272 | Wartung_FFB | 2 | Pset_MEP - Geom-Connection diameter (mm): 630 m
Quellluftauslass | Wartung_FFB | 37 | 160 | 250 | 500 | 70.9711 | 300 | 212 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 36 | 160 | 250 | 500 | 69.6057 | 300 | 221 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 29 | 160 | 250 | 500 | 44.8217 | 325 | 298 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 30 | 160 | 250 | 500 | 48.9736 | 325 | 283 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 32 | 160 | 250 | 500 | 60.5558 | 325 | 261 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 33 | 160 | 250 | 500 | 61.9286 | 325 | 252 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 34 | 160 | 250 | 500 | 64.0359 | 325 | 239 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 35 | 160 | 250 | 500 | 65.1407 | 325 | 230 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 27 | 160 | 250 | 500 | 34.1336 | 325 | 325 | Wartung_FFB | 2
Quellluftauslass | Wartung_FFB | 28 | 160 | 250 | 500 | 41.6093 | 325 | 313 | Wartung_FFB | 2
Quellluftauslass | EG_Verwaltung_FFB | 26 | 160 | 250 | 500 | 3.72548 | 375 | 337 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 24 | 160 | 250 | 500 | 0 | 375 | 348 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 120 | 160 | 250 | 500 | 0 | 325 | 314 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 122 | 160 | 250 | 500 | 11.1009 | 325 | 297 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 124 | 160 | 250 | 500 | 19.7393 | 325 | 280 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 126 | 160 | 250 | 500 | 30.1047 | 325 | 262 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 128 | 160 | 250 | 500 | 32.3833 | 325 | 247 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 130 | 160 | 250 | 500 | 41.5186 | 325 | 229 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 132 | 160 | 250 | 500 | 43.8675 | 325 | 214 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 135 | 160 | 250 | 500 | 48.0621 | 325 | 183 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 137 | 160 | 250 | 500 | 79.1378 | 325 | 165 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 139 | 160 | 250 | 500 | 97.187 | 325 | 147 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 141 | 160 | 250 | 500 | 100.428 | 325 | 133 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 105 | 160 | 250 | 500 | 115.085 | 300 | 326 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 103 | 160 | 250 | 500 | 113.485 | 300 | 341 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 101 | 160 | 250 | 500 | 112.329 | 300 | 355 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 99 | 160 | 250 | 500 | 110.781 | 300 | 372 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 97 | 160 | 250 | 500 | 109.268 | 300 | 386 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 95 | 160 | 250 | 500 | 107.538 | 300 | 401 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 93 | 160 | 250 | 500 | 106.104 | 300 | 416 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 90 | 160 | 250 | 500 | 98.771 | 300 | 442 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 55 | 160 | 250 | 500 | 39.0277 | 325 | 155 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 58 | 160 | 250 | 500 | 46.4287 | 325 | 129 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 60 | 160 | 250 | 500 | 48.0571 | 325 | 114 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 62 | 160 | 250 | 500 | 49.3919 | 325 | 100 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 64 | 160 | 250 | 500 | 51.2805 | 325 | 85 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 66 | 160 | 250 | 500 | 53.2533 | 325 | 66 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 68 | 160 | 250 | 500 | 54.372 | 325 | 52 | EG_Verwaltung_FFB | 0
Quellluftauslass | EG_Verwaltung_FFB | 70 | 160 | 250 | 500 | 65.7217 | 325 | 29 | EG_Verwaltung_FFB | 0

# IfcFlowTerminal: WSG 1 Halle FOL (5)
In: Wartung_FFB
Description: WSG 1 Halle FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 95 mm; Calc-Pressure loss (Pa): 0 Pa; Name: WSG 1 Halle FOL; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Tech-Medium | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Section No | Pos. No.
2 x WSG 1 Halle FOL | 923 | 1700 | L_Zuluft | 0 | 200
WSG 1 Halle FOL | 923 | 3460 | L_Fortluft | 0 | 16300 | 2 | 49
WSG 1 Halle FOL | 923 | 3460 | L_Fortluft | 1.98457 | 16300 | 3 | 41
WSG 1 Halle FOL | 1982 | 3059 | L_Aussenluft | 0 | 32600 | 8 | 128

# IfcFlowTerminal: WSG 2 Halle FOL (2)
In: Wartung_FFB
Description: WSG 2 Halle FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Side 1 (mm): 923 mm; Geom-Side 2 (mm): 1700 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Zuluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 200 m3/hour; Name: WSG 2 Halle FOL; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Büro+Aufenth. AUL
In: Wartung_FFB
Description: WSG Büro+Aufenth. AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 93; Geom-Side 1 (mm): 1253 mm; Geom-Side 2 (mm): 1300 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Aussenluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 10190 m3/hour; Name: WSG Büro+Aufenth. AUL; Pos. No.: 915; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Büro+Aufenth. FOL
In: Wartung_FFB
Description: WSG Büro+Aufenth. FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Side 1 (mm): 1253 mm; Geom-Side 2 (mm): 1300 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Fortluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 10190 m3/hour; Name: WSG Büro+Aufenth. FOL; Pos. No.: 26; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Halle AUL (2)
In: Wartung_FFB
Description: WSG Halle AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Side 1 (mm): 1983 mm; Geom-Side 2 (mm): 1500 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Zuluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 200 m3/hour; Name: WSG Halle AUL; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Kaltarbeitsp. AUL
In: Wartung_FFB
Description: WSG Kaltarbeitsp. AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 28; Geom-Side 1 (mm): 675 mm; Geom-Side 2 (mm): 700 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Aussenluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 3300 m3/hour; Name: WSG Kaltarbeitsp. AUL; Pos. No.: 297; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Kaltarbeitsp. FOL
In: Wartung_FFB
Description: WSG Kaltarbeitsp. FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Side 1 (mm): 675 mm; Geom-Side 2 (mm): 700 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Fortluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 3300 m3/hour; Name: WSG Kaltarbeitsp. FOL; Pos. No.: 33; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Lager/Werkstatt AUL
In: Wartung_FFB
Description: WSG Lager/Werkstatt AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 17; Geom-Side 1 (mm): 675 mm; Geom-Side 2 (mm): 800 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Aussenluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 3520 m3/hour; Name: WSG Lager/Werkstatt AUL; Pos. No.: 156; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Lager/Werkstatt FOL
In: Wartung_FFB
Description: WSG Lager/Werkstatt FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Side 1 (mm): 675 mm; Geom-Side 2 (mm): 800 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Fortluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 3520 m3/hour; Name: WSG Lager/Werkstatt FOL; Pos. No.: 27; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Spülküche AUL (8)
In: Wartung_FFB
Description: WSG Spülküche AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 95 mm; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Name: WSG Spülküche AUL; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Tech-Medium | Calc-Volumetric flow (m3/h) (m3/hour)
WSG Spülküche AUL | 2274 | 4060 | L_Fortluft | 41900 | Pset_MEP - Section No: 81; Pos. No.: 555
6 x WSG Spülküche AUL | 1057 | 1576 | L_Zuluft | 200
WSG Spülküche AUL | 2174 | 4848 | L_Aussenluft | 45900 | Pset_MEP - Section No: 193; Pos. No.: 684

# IfcFlowTerminal: WSG Spülküche FOL (4)
In: Wartung_FFB
Description: WSG Spülküche FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Side 1 (mm): 1107 mm; Geom-Side 2 (mm): 2000 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Zuluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 200 m3/hour; Name: WSG Spülküche FOL; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Technik AUL
In: Wartung_FFB
Description: WSG Technik AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 53; Geom-Side 1 (mm): 758 mm; Geom-Side 2 (mm): 800 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Aussenluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 4120 m3/hour; Name: WSG Technik AUL; Pos. No.: 608; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Technik FOL
In: Wartung_FFB
Description: WSG Technik FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Side 1 (mm): 758 mm; Geom-Side 2 (mm): 800 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Fortluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 4120 m3/hour; Name: WSG Technik FOL; Pos. No.: 30; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Warmarbeitsp. AUL
In: Wartung_FFB
Description: WSG Warmarbeitsp. AUL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Side 1 (mm): 510 mm; Geom-Side 2 (mm): 700 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Aussenluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 2530 m3/hour; Name: WSG Warmarbeitsp. AUL; Pos. No.: 50; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: WSG Warmarbeitsp. FOL
In: Wartung_FFB
Description: WSG Warmarbeitsp. FOL
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 30; Geom-Side 1 (mm): 510 mm; Geom-Side 2 (mm): 700 mm; Geom-Length (mm): 95 mm; Tech-Medium: L_Fortluft; Calc-Pressure loss (Pa): 0 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 2530 m3/hour; Name: WSG Warmarbeitsp. FOL; Pos. No.: 395; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTreatmentDevice: Filter, Allgemein (6)
In: Wartung_FFB
Description: Filter, Allgemein
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Side 2 (mm): 2448 mm; Calc-Zeta: 2; Name: Filter, Allgemein; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Side 1 (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Filter, Allgemein | 1 | 2448 | 1071 | L_Abluft | 2.88675 | 8
Filter, Allgemein | 1 | 2448 | 1454 | L_Zuluft | 3.19206 | 2
Filter, Allgemein | 1 | 2448 | 1377 | L_Abluft | 2.88675 | 7
Filter, Allgemein | 1 | 2142 | 1454 | L_Zuluft | 3.22058 | 2
Filter, Allgemein | 8 | 2142 | 1683 | L_Aussenluft | 3.5789 | 76
Filter, Allgemein | 4 | 2142 | 1377 | L_Abluft | 3.62295 | 51

# IfcFlowTreatmentDevice: Schalldämpfer (44)
In: Wartung_FFB
Description: Schalldämpfer
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Calc-Zeta: 2; Name: Schalldämpfer; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Schalldämpfer | 1 | 918 | 1530 | 1071 | L_Zuluft | 4.80694 | 2
Schalldämpfer | 93 | 1530 | 918 | 995 | L_Aussenluft | 4.87367 | 878
Schalldämpfer | 1 | 918 | 1530 | 1071 | L_Fortluft | 4.87367 | 2
Schalldämpfer | 2 | 1530 | 918 | 1071 | L_Abluft | 4.87367 | 30
Schalldämpfer | 1 | 612 | 918 | 1071 | L_Zuluft | 3.1946 | 2
Schalldämpfer | 28 | 612 | 918 | 995 | L_Aussenluft | 3.1946 | 259
Schalldämpfer | 2 | 918 | 612 | 995 | L_Abluft | 3.1946 | 38
Schalldämpfer | 1 | 612 | 918 | 1071 | L_Fortluft | 3.1946 | 2
Schalldämpfer | 2 | 612 | 612 | 1071 | L_Zuluft | 4.22485 | 51
Schalldämpfer | 1 | 612 | 612 | 995 | L_Aussenluft | 4.22485 | 8
Schalldämpfer | 1 | 612 | 612 | 1454 | L_Abluft | 4.42762 | 5
Schalldämpfer | 30 | 612 | 612 | 1071 | L_Fortluft | 4.22485 | 361
Schalldämpfer | 1 | 612 | 918 | 1071 | L_Zuluft | 3.63474 | 2
Schalldämpfer | 17 | 612 | 918 | 995 | L_Aussenluft | 3.63474 | 123
Schalldämpfer | 2 | 612 | 918 | 1071 | L_Abluft | 3.63474 | 32
Schalldämpfer | 1 | 612 | 918 | 1071 | L_Fortluft | 3.63474 | 2
Schalldämpfer | 1 | 612 | 918 | 1071 | L_Zuluft | 6.39767 | 2
Schalldämpfer | 53 | 918 | 612 | 995 | L_Aussenluft | 4.97946 | 569
Schalldämpfer | 2 | 612 | 918 | 1071 | L_Abluft | 6.23433 | 35
Schalldämpfer | 1 | 612 | 918 | 1071 | L_Fortluft | 4.97946 | 2
Schalldämpfer | 193 | 2448 | 2448 | 1836 | L_Aussenluft | 5.43195 | 650
Schalldämpfer | 1 | 2448 | 2448 | 1377 | L_Zuluft | 3.19206 | 3
Schalldämpfer | 1 | 2448 | 2448 | 1836 | L_Abluft | 2.88675 | 6
Schalldämpfer | 81 | 2448 | 2448 | 1377 | L_Fortluft | 4.52646 | 526
Schalldämpfer | 1 | 2142 | 2448 | 1377 | L_Zuluft | 3.22058 | 3
Schalldämpfer | 8 | 2142 | 2448 | 1377 | L_Aussenluft | 3.5789 | 75
Schalldämpfer | 4 | 2142 | 2448 | 1836 | L_Abluft | 3.62295 | 50
Schalldämpfer | 1 | 2142 | 2448 | 1377 | L_Fortluft | 3.5789 | 4
Schalldämpfer | 171 | 700 | 500 | 1000 | L_Zuluft | 16.8393 | 309
Schalldämpfer | 4 | 700 | 500 | 1000 | L_Abluft | 18.6028 | 456
Schalldämpfer | 33 | 1300 | 1400 | 1000 | L_Zuluft | 12.2208 | 23
Schalldämpfer | 53 | 500 | 800 | 1000 | L_Abluft | 16.875 | 184
Schalldämpfer | 61 | 400 | 700 | 1000 | L_Abluft | 15.3061 | 133
Schalldämpfer | 69 | 500 | 800 | 1000 | L_Abluft | 16.875 | 88
Schalldämpfer | 7 | 350 | 300 | 1000 | L_Zuluft | 15.3061 | 593
Schalldämpfer | 18 | 350 | 500 | 1000 | L_Zuluft | 14.66 | 528
Schalldämpfer | 35 | 400 | 800 | 1000 | L_Abluft | 18.3105 | 312
Schalldämpfer | 43 | 550 | 300 | 1000 | L_Abluft | 16.4609 | 278
Schalldämpfer | 47 | 350 | 300 | 1000 | L_Abluft | 15.3061 | 243
Schalldämpfer | 77 | 500 | 300 | 1000 | L_Abluft | 16.4609 | 52
Schalldämpfer | 17 | 400 | 500 | 1000 | L_Abluft | 16.875 | 377
Schalldämpfer | 17 | 300 | 350 | 1000 | L_Abluft | 15.3061 | 377
Schalldämpfer | 17 | 400 | 350 | 1000 | L_Zuluft | 14.4676 | 377
Schalldämpfer | 17 | 500 | 350 | 1000 | L_Zuluft | 14.4676 | 377

# IfcFlowTreatmentDevice: Telefonieschalldämpfer (232)
Description: Telefonieschalldämpfer
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1000 mm; Calc-Zeta: 2; Name: Telefonieschalldämpfer; Abbreviation: B.RSD; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Outer diameter (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No.
Telefonieschalldämpfer | Wartung_FFB | 52 | 100 | 200 | L_Abluft | 15.0105 | 147 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 47 | 100 | 200 | L_Zuluft | 15.0105 | 116 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 50 | 100 | 200 | L_Zuluft | 15.0105 | 86 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 55 | 100 | 200 | L_Abluft | 15.0105 | 118 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 51 | 100 | 200 | L_Zuluft | 15.0105 | 64 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 56 | 100 | 150 | L_Abluft | 15.0105 | 95 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 52 | 100 | 200 | L_Zuluft | 15.0105 | 34 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 57 | 100 | 150 | L_Abluft | 15.0105 | 68 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 51 | 100 | 200 | L_Abluft | 15.0105 | 178 | Wartung_FFB | 2
Telefonieschalldämpfer | Wartung_FFB | 46 | 100 | 200 | L_Zuluft | 15.0105 | 145 | Wartung_FFB | 2
Telefonieschalldämpfer | EG_Verwaltung_FFB | 37 | 160 | 260 | L_Zuluft | 11.0857 | 645 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 39 | 160 | 260 | L_Abluft | 11.0857 | 700 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 40 | 100 | 200 | L_Abluft | 18.1628 | 681 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 38 | 100 | 200 | L_Zuluft | 18.1628 | 622 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 53 | 125 | 225 | L_Zuluft | 8.85358 | 441 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 56 | 125 | 225 | L_Abluft | 8.85358 | 465 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 48 | 100 | 200 | L_Abluft | 5.4038 | 609 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 47 | 100 | 200 | L_Zuluft | 5.4038 | 560 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 37 | 140 | 240 | L_Abluft | 15.6295 | 732 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 35 | 140 | 240 | L_Zuluft | 15.6295 | 681 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 32 | 125 | 225 | L_Zuluft | 7.43947 | 728 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 33 | 125 | 225 | L_Abluft | 7.43947 | 785 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 30 | 125 | 225 | L_Zuluft | 10.3907 | 764 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 32 | 125 | 225 | L_Abluft | 10.3907 | 799 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 36 | 140 | 240 | L_Abluft | 13.373 | 745 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 34 | 140 | 240 | L_Zuluft | 13.373 | 697 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 34 | 140 | 240 | L_Abluft | 13.373 | 769 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 31 | 140 | 240 | L_Zuluft | 13.373 | 743 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 48 | 100 | 200 | L_Zuluft | 5.4038 | 538 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 50 | 100 | 200 | L_Abluft | 5.4038 | 580 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 36 | 125 | 225 | L_Zuluft | 10.3907 | 662 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 38 | 125 | 225 | L_Abluft | 10.3907 | 715 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 41 | 160 | 260 | L_Zuluft | 11.0857 | 589 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 42 | 160 | 260 | L_Abluft | 11.0857 | 643 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 39 | 160 | 260 | L_Zuluft | 11.0857 | 612 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 41 | 160 | 260 | L_Abluft | 11.0857 | 664 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 53 | 100 | 200 | L_Abluft | 9.60675 | 514 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 52 | 100 | 200 | L_Zuluft | 9.60675 | 463 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 49 | 100 | 200 | L_Zuluft | 5.4038 | 517 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 43 | 125 | 225 | L_Abluft | 12.0507 | 627 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 42 | 125 | 225 | L_Zuluft | 12.0507 | 579 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 200 | 300 | L_Abluft | 17.7523 | 831 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 100 | 200 | L_Abluft | 18.1628 | 870 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 100 | 200 | L_Zuluft | 18.1628 | 833 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 125 | 225 | L_Abluft | 10.3907 | 910 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 125 | 225 | L_Zuluft | 10.3907 | 866 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 140 | 240 | L_Abluft | 12.6599 | 890 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 140 | 240 | L_Abluft | 17.2315 | 853 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 140 | 240 | L_Zuluft | 17.2315 | 818 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 90 | 125 | 225 | L_Zuluft | 15.7397 | 83 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 88 | 125 | 225 | L_Abluft | 12.0507 | 144 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 65 | 125 | 225 | L_Zuluft | 12.0507 | 339 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 63 | 100 | 200 | L_Zuluft | 2.40169 | 348 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 87 | 100 | 200 | L_Abluft | 2.40169 | 161 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 90 | 100 | 200 | L_Abluft | 7.35517 | 128 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 91 | 100 | 200 | L_Abluft | 12.1585 | 111 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 68 | 100 | 200 | L_Zuluft | 12.1585 | 305 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 67 | 100 | 200 | L_Zuluft | 7.35517 | 324 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 76 | 180 | 280 | L_Abluft | 12.8691 | 288 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 85 | 180 | 280 | L_Zuluft | 12.8691 | 162 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 80 | 125 | 225 | L_Abluft | 8.85358 | 222 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 89 | 125 | 225 | L_Zuluft | 8.85358 | 97 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 78 | 140 | 240 | L_Abluft | 11.2923 | 254 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 87 | 140 | 240 | L_Zuluft | 11.2923 | 128 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 75 | 160 | 260 | L_Abluft | 16.6972 | 302 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 84 | 160 | 260 | L_Zuluft | 16.6972 | 176 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 73 | 125 | 225 | L_Abluft | 12.0507 | 333 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 83 | 125 | 225 | L_Zuluft | 12.0507 | 192 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 82 | 160 | 260 | L_Zuluft | 14.3152 | 207 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 74 | 160 | 260 | L_Abluft | 14.3152 | 319 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 81 | 200 | 300 | L_Zuluft | 18.1628 | 224 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 79 | 200 | 300 | L_Zuluft | 17.7523 | 255 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 70 | 200 | 300 | L_Abluft | 17.7523 | 381 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 72 | 200 | 300 | L_Abluft | 18.1628 | 351 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 80 | 200 | 300 | L_Zuluft | 17.7523 | 241 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 71 | 200 | 300 | L_Abluft | 17.7523 | 368 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 86 | 140 | 240 | L_Zuluft | 15.6295 | 142 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 77 | 140 | 240 | L_Abluft | 15.6295 | 268 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 79 | 140 | 240 | L_Abluft | 12.6599 | 237 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 88 | 140 | 240 | L_Zuluft | 12.6599 | 111 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 69 | 160 | 260 | L_Zuluft | 12.6489 | 282 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 93 | 160 | 260 | L_Abluft | 12.6489 | 74 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 70 | 160 | 260 | L_Zuluft | 12.6489 | 271 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 92 | 160 | 260 | L_Abluft | 12.6489 | 85 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 91 | 160 | 260 | L_Zuluft | 12.6489 | 62 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 83 | 160 | 260 | L_Abluft | 12.6489 | 176 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 81 | 125 | 225 | L_Abluft | 15.7397 | 206 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 200 | 300 | L_Abluft | 17.7523 | 838 | EG_Verwaltung_FFB | 0
