Properties of the parts of a building model (IFC2X3), part 18 of 18

# IfcFlowTreatmentDevice: Telefonieschalldämpfer (232)
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Outer diameter (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No.
Telefonieschalldämpfer | EG_Verwaltung_FFB | 58 | 200 | 300 | L_Abluft | 17.7523 | 435 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 57 | 200 | 300 | L_Zuluft | 17.7523 | 402 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 58 | 200 | 300 | L_Zuluft | 17.7523 | 394 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 55 | 200 | 300 | L_Zuluft | 17.7523 | 412 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 33 | 125 | 225 | L_Zuluft | 1.53708 | 715 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 35 | 125 | 225 | L_Abluft | 1.53708 | 757 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 54 | 100 | 200 | L_Abluft | 10.8451 | 498 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 40 | 125 | 225 | L_Zuluft | 8.13115 | 599 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 49 | 100 | 200 | L_Abluft | 10.8451 | 593 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 22 | 140 | 240 | L_Abluft | 14.8578 | 565 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 140 | 240 | L_Zuluft | 14.8578 | 533 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 140 | 240 | L_Zuluft | 14.1056 | 549 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 140 | 240 | L_Zuluft | 14.8578 | 560 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 24 | 140 | 240 | L_Abluft | 14.8578 | 534 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 23 | 140 | 240 | L_Abluft | 14.1056 | 550 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 25 | 140 | 240 | L_Abluft | 14.1056 | 501 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 26 | 140 | 240 | L_Abluft | 14.1056 | 482 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 140 | 240 | L_Zuluft | 14.1056 | 503 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 20 | 140 | 240 | L_Zuluft | 14.1056 | 448 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 29 | 140 | 240 | L_Abluft | 14.1056 | 443 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 19 | 140 | 240 | L_Zuluft | 14.1056 | 463 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 18 | 140 | 240 | L_Zuluft | 14.1056 | 486 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 28 | 140 | 240 | L_Abluft | 14.1056 | 467 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 30 | 200 | 300 | L_Abluft | 15.0105 | 421 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 21 | 200 | 300 | L_Zuluft | 15.0105 | 419 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 34 | 140 | 240 | L_Abluft | 17.2315 | 365 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 40 | 140 | 240 | L_Zuluft | 17.2315 | 217 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 125 | 240 | L_Abluft | 17.7686 | 615 | EG_Verwaltung_FFB | 0
2 x Telefonieschalldämpfer | EG_Verwaltung_FFB |  | 125 | 225 | L_Zuluft | 17.7686 |  | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB |  | 125 | 225 | L_Zuluft | 10.3907 |  | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 125 | 240 | L_Abluft | 17.7686 | 600 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 125 | 240 | L_Abluft | 10.3907 | 584 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 27 | 125 | 225 | L_Zuluft | 8.85358 | 371 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 37 | 125 | 225 | L_Abluft | 8.85358 | 352 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 28 | 140 | 240 | L_Zuluft | 17.2315 | 351 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 39 | 140 | 240 | L_Zuluft | 17.2315 | 246 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 47 | 140 | 240 | L_Abluft | 17.2315 | 256 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 49 | 140 | 240 | L_Abluft | 17.2315 | 216 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 48 | 100 | 200 | L_Abluft | 2.40169 | 238 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 38 | 100 | 200 | L_Zuluft | 2.40169 | 260 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 46 | 100 | 200 | L_Abluft | 2.40169 | 271 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 36 | 100 | 200 | L_Zuluft | 2.40169 | 293 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 45 | 100 | 200 | L_Abluft | 5.4038 | 287 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 37 | 100 | 200 | L_Zuluft | 5.4038 | 278 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 7 | 200 | 300 | L_Abluft | 18.9977 | 630 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 23 | 200 | 300 | L_Zuluft | 9.60675 | 390 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 16 | 200 | 300 | L_Abluft | 18.1628 | 53 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 200 | 300 | L_Abluft | 18.1628 | 68 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 200 | 300 | L_Abluft | 18.1628 | 78 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 200 | 300 | L_Zuluft | 18.1628 | 33 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 16 | 200 | 300 | L_Zuluft | 18.1628 | 18 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 200 | 300 | L_Zuluft | 18.1628 | 47 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 200 | 300 | L_Zuluft | 18.1628 | 61 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 200 | 300 | L_Zuluft | 18.1628 | 76 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 9 | 200 | 300 | L_Zuluft | 18.1628 | 114 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 200 | 300 | L_Zuluft | 18.1628 | 102 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 200 | 300 | L_Zuluft | 18.1628 | 92 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 200 | 300 | L_Abluft | 18.1628 | 124 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 200 | 300 | L_Abluft | 18.1628 | 99 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 200 | 300 | L_Abluft | 18.1628 | 140 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 9 | 200 | 300 | L_Abluft | 18.1628 | 150 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 200 | 300 | L_Abluft | 18.1628 | 108 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 16 | 125 | 225 | L_Abluft | 10.3907 | 232 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 125 | 225 | L_Zuluft | 10.3907 | 274 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 16 | 125 | 225 | L_Zuluft | 7.43947 | 256 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 17 | 125 | 225 | L_Abluft | 7.43947 | 217 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 20 | 125 | 225 | L_Abluft | 15.7397 | 164 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 19 | 125 | 225 | L_Zuluft | 15.7397 | 201 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 18 | 125 | 225 | L_Zuluft | 15.7397 | 221 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 19 | 125 | 225 | L_Abluft | 15.7397 | 184 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 100 | 200 | L_Abluft | 5.4038 | 249 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 125 | 225 | L_Abluft | 29.7579 | 263 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 160 | 260 | L_Zuluft | 11.0857 | 290 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 9 | 180 | 280 | L_Zuluft | 14.1882 | 363 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 8 | 180 | 280 | L_Zuluft | 14.1882 | 375 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 7 | 180 | 280 | L_Abluft | 14.1882 | 353 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 8 | 180 | 280 | L_Abluft | 14.1882 | 345 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 100 | 200 | L_Zuluft | 5.4038 | 332 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 100 | 200 | L_Zuluft | 5.4038 | 347 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 100 | 200 | L_Abluft | 5.4038 | 312 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 9 | 100 | 200 | L_Abluft | 5.4038 | 329 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 27 | 100 | 200 | L_Abluft | 12.1585 | 94 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 25 | 100 | 200 | L_Zuluft | 12.1585 | 155 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 29 | 160 | 260 | L_Abluft | 17.3214 | 64 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 28 | 160 | 260 | L_Abluft | 17.3214 | 78 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 26 | 125 | 225 | L_Abluft | 12.0507 | 112 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 24 | 125 | 225 | L_Zuluft | 12.0507 | 174 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 26 | 160 | 260 | L_Zuluft | 17.3214 | 139 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 27 | 160 | 260 | L_Zuluft | 17.3214 | 119 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 22 | 160 | 260 | L_Abluft | 11.0857 | 140 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 28 | 160 | 260 | L_Zuluft | 11.0857 | 103 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 6 | 160 | 260 | L_Zuluft | 14.3152 | 225 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 5 | 160 | 260 | L_Zuluft | 14.3152 | 249 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 7 | 160 | 260 | L_Abluft | 14.3152 | 281 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 160 | 260 | L_Abluft | 13.1929 | 265 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 6 | 160 | 260 | L_Abluft | 14.3152 | 301 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 160 | 260 | L_Abluft | 14.3152 | 257 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 160 | 260 | L_Zuluft | 14.3152 | 202 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 12 | 160 | 260 | L_Zuluft | 14.3152 | 187 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 160 | 260 | L_Abluft | 14.3152 | 216 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 100 | 200 | L_Zuluft | 15.0105 | 168 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 13 | 100 | 200 | L_Abluft | 15.0105 | 237 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 43 | 100 | 200 | L_Abluft | 2.40169 | 321 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 34 | 100 | 200 | L_Zuluft | 2.40169 | 327 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 44 | 100 | 200 | L_Abluft | 2.40169 | 305 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 35 | 100 | 200 | L_Zuluft | 2.40169 | 311 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 82 | 160 | 260 | L_Abluft | 12.6489 | 190 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 92 | 160 | 260 | L_Zuluft | 12.6489 | 48 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 1 | 200 | 300 | L_Fortluft | 5 | 3 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 26 | 160 | 260 | L_Zuluft | 13.7483 | 59 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 26 | 160 | 260 | L_Abluft | 13.7483 | 121 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 25 | 160 | 260 | L_Zuluft | 13.7483 | 71 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 27 | 160 | 260 | L_Abluft | 13.7483 | 109 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 23 | 160 | 260 | L_Zuluft | 13.7483 | 89 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 21 | 160 | 260 | L_Zuluft | 13.7483 | 117 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 27 | 160 | 260 | L_Zuluft | 13.7483 | 41 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 20 | 160 | 260 | L_Zuluft | 13.7483 | 130 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 19 | 160 | 260 | L_Zuluft | 13.7483 | 143 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 22 | 160 | 260 | L_Abluft | 13.7483 | 162 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 28 | 160 | 260 | L_Abluft | 13.7483 | 87 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 23 | 160 | 260 | L_Abluft | 13.7483 | 152 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 22 | 160 | 260 | L_Zuluft | 13.7483 | 100 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 24 | 160 | 260 | L_Abluft | 13.7483 | 138 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 20 | 160 | 260 | L_Abluft | 13.7483 | 195 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 14 | 200 | 300 | L_Zuluft | 17.7523 | 797 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 15 | 200 | 300 | L_Zuluft | 17.7523 | 782 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 16 | 200 | 300 | L_Zuluft | 17.7523 | 774 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 59 | 200 | 300 | L_Abluft | 17.7523 | 425 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 55 | 100 | 200 | L_Abluft | 5.4038 | 481 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 16 | 200 | 300 | L_Abluft | 17.7523 | 816 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 41 | 200 | 300 | L_Zuluft | 18.9977 | 193 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 22 | 125 | 225 | L_Zuluft | 15.7397 | 401 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 31 | 125 | 225 | L_Abluft | 15.7397 | 398 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 10 | 160 | 260 | L_Zuluft | 13.1929 | 212 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 11 | 140 | 240 | L_Zuluft | 4.72792 | 849 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 51 | 125 | 225 | L_Zuluft | 8.13115 | 481 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 50 | 100 | 200 | L_Zuluft | 5.4038 | 498 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 52 | 100 | 200 | L_Abluft | 5.4038 | 536 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 45 | 200 | 300 | L_Zuluft | 5 | 175 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 21 | 160 | 260 | L_Abluft | 13.7483 | 184 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 51 | 100 | 200 | L_Abluft | 5.4038 | 556 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 57 | 200 | 300 | L_Abluft | 17.7523 | 445 | EG_Verwaltung_FFB | 0
Telefonieschalldämpfer | EG_Verwaltung_FFB | 23 | 200 | 300 | L_Abluft | 9.60675 | 390 | EG_Verwaltung_FFB | 0
