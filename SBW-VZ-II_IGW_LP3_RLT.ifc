Properties of the parts of a building model (IFC2X3), part 8 of 18

# IfcFlowSegment: Luftleitung (1382)
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 612 | 612 | 918 | 2.24726 | L_Aussenluft | 14.3825 | 2530 | 1.87636 | 0.0637701 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 368 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1258.28 | 2.26491 | L_Aussenluft | 10.8716 | 2530 | 3.51389 | 0.409761 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1095.71 | 1.97229 | L_Aussenluft | 9.46698 | 2530 | 3.51389 | 0.356821 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 400 | 500 | 1378.56 | 2.48142 | L_Fortluft | 11.9108 | 2530 | 3.51389 | 0.448931 | 366 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 903 | 1.806 | L_Fortluft | 8.6688 | 3300 | 3.66667 | 0.275506 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 64 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 63 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 62 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 61 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 60 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 59 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1350 | 2.43 | L_Zuluft | 11.664 | 2530 | 3.51389 | 0.439629 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 400 | 500 | 1188.34 | 2.13902 | L_Zuluft | 10.2673 | 2530 | 3.51389 | 0.386985 | 58 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1237.74 | 2.22794 | L_Abluft | 10.6941 | 2590 | 3.59722 | 0.420963 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1000 | 1.8 | L_Abluft | 8.64 | 2590 | 3.59722 | 0.340106 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 612 | 918 | 917.997 | 2.80907 | L_Aussenluft | 17.9781 | 3520 | 1.74039 | 0.0444779 | 124 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 131 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 132 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 133 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 135 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 450 | 600 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 142 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 149 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 148 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 147 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 146 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 979 | 2.0559 | L_Aussenluft | 13.1578 | 3520 | 3.6214 | 0.282014 | 145 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 450 | 600 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 450 | 600 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 450 | 600 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 450 | 600 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1079.65 | 2.26726 | L_Zuluft | 14.5105 | 3520 | 3.6214 | 0.311007 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 600 | 450 | 904 | 1.8984 | L_Abluft | 12.1498 | 3520 | 3.6214 | 0.260409 | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 450 | 600 | 1500 | 3.15 | L_Abluft | 20.16 | 3520 | 3.6214 | 0.432095 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 450 | 600 | 1500 | 3.15 | L_Abluft | 20.16 | 3520 | 3.6214 | 0.432095 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 450 | 600 | 1500 | 3.15 | L_Abluft | 20.16 | 3520 | 3.6214 | 0.432095 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 600 | 500 | 1500 | 3.3 | L_Abluft | 21.12 | 4610 | 4.26852 | 0.546031 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 600 | 500 | 1500 | 3.3 | L_Abluft | 21.12 | 4610 | 4.26852 | 0.546031 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 500 | 1021.37 | 2.247 | L_Abluft | 14.3808 | 4310 | 3.99074 | 0.327995 | 124 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 918 | 612 | 1208.66 | 3.6985 | L_Aussenluft | 23.6704 | 4120 | 2.03704 | 0.078076 | 570 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 577 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 578 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 579 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 580 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 581 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 582 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 583 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1000 | 2.2 | L_Aussenluft | 14.08 | 4120 | 3.81481 | 0.295303 | 584 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 601 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 600 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 599 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1208.32 | 2.6583 | L_Aussenluft | 17.0131 | 4120 | 3.81481 | 0.35682 | 598 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 594 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 595 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2000 | 1800 | 1500 | 11.4 | L_Zuluft | 91.2 | 35186 | 2.71497 | 0.0523726 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2448 | 2448 | 1500 | 14.688 | L_Aussenluft | 129.254 | 45900 | 2.12759 | 0.0245522 | 647 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2448 | 2448 | 902.336 | 8.83567 | L_Aussenluft | 77.7539 | 45900 | 2.12759 | 0.0147696 | 648 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2448 | 2448 | 1500 | 14.688 | L_Abluft | 129.254 | 33461 | 1.55101 | 0.0137196 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2448 | 2448 | 902.336 | 8.83567 | L_Abluft | 77.7539 | 33461 | 1.55101 | 0.00825314 | 3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 2142 | 2448 | 1000 | 9.18 | L_Aussenluft | 80.784 | 32600 | 1.72697 | 0.0121029 | 74 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2142 | 2448 | 1000 | 9.18 | L_Fortluft | 80.784 | 32600 | 1.72697 | 0.0121029 | 2 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 1400 | 500 | 1200 | 4.56 | L_Abluft | 36.48 | 8200 | 3.25397 | 0.182967 | 143 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 954.587 | 1.90917 | L_Fortluft | 9.16403 | 3300 | 3.66667 | 0.291245 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 371 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1008.03 | 1.81445 | L_Fortluft | 8.70934 | 2530 | 3.51389 | 0.328265 | 372 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 13 | 1400 | 500 | 1200 | 4.56 | L_Abluft | 36.48 | 8200 | 3.25397 | 0.182967 | 122 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 1400 | 500 | 1200 | 4.56 | L_Abluft | 36.48 | 8200 | 3.25397 | 0.182967 | 94 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 1400 | 500 | 1200 | 4.56 | L_Abluft | 36.48 | 8200 | 3.25397 | 0.182967 | 83 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1000 | 1200 | 1500 | 6.6 | L_Abluft | 52.8 | 16400 | 3.7963 | 0.189531 | 119 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 80 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 2000 | 1200 | 1079.22 | 6.90701 | L_Abluft | 55.2561 | 32800 | 3.7963 | 0.0930138 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 1200 | 2000 | 1500 | 9.6 | L_Abluft | 76.8 | 32800 | 3.7963 | 0.129279 | 59 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 1200 | 2000 | 1500 | 9.6 | L_Abluft | 76.8 | 32800 | 3.7963 | 0.129279 | 60 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 1200 | 2000 | 1500 | 9.6 | L_Abluft | 76.8 | 32800 | 3.7963 | 0.129279 | 61 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1200 | 1500 | 1500 | 8.1 | L_Abluft | 64.8 | 24600 | 3.7963 | 0.148896 | 91 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1200 | 1500 | 1500 | 8.1 | L_Abluft | 64.8 | 24600 | 3.7963 | 0.148896 | 89 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1200 | 1500 | 929.676 | 5.02025 | L_Abluft | 40.162 | 24600 | 3.7963 | 0.0922832 | 90 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 600 | 1800 | 1500 | 7.2 | L_Abluft | 57.6 | 16400 | 4.21811 | 0.290964 | 108 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 2142 | 2000 | 1368.7 | 11.3384 | L_Abluft | 99.7775 | 32800 | 2.12678 | 0.0273849 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 129 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 130 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 131 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 132 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 83 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 463 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 83 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 462 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 83 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 461 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 83 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 460 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 82 | 350 | 300 | 997.995 | 1.29739 | L_Zuluft | 6.22749 | 1300 | 3.43915 | 0.462217 | 450 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1600 | 3.62812 | 0.694951 | 432 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 82 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 444 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 79 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 6200 | 4.30556 | 0.479164 | 406 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1600 | 3.62812 | 0.694951 | 431 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1600 | 3.62812 | 0.694951 | 430 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 78 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6500 | 3.76157 | 0.326663 | 391 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 79 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 6200 | 4.30556 | 0.479164 | 405 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 79 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 6200 | 4.30556 | 0.479164 | 404 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 79 | 500 | 800 | 1270.16 | 3.30242 | L_Zuluft | 21.1355 | 6200 | 4.30556 | 0.405744 | 403 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 78 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6500 | 3.76157 | 0.326663 | 390 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 78 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6500 | 3.76157 | 0.326663 | 389 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 78 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6500 | 3.76157 | 0.326663 | 388 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 350 | 350 | 1000 | 1.4 | L_Zuluft | 6.72 | 1600 | 3.62812 | 0.463301 | 429 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 78 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6500 | 3.76157 | 0.326663 | 387 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 77 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6800 | 3.93519 | 0.355281 | 376 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 77 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6800 | 3.93519 | 0.355281 | 375 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 77 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6800 | 3.93519 | 0.355281 | 374 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 77 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6800 | 3.93519 | 0.355281 | 373 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 76 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7100 | 4.1088 | 0.385046 | 362 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 76 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7100 | 4.1088 | 0.385046 | 361 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 76 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7100 | 4.1088 | 0.385046 | 360 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 76 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7100 | 4.1088 | 0.385046 | 359 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 75 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7400 | 3.67063 | 0.281484 | 345 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 76 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7100 | 4.1088 | 0.385046 | 358 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 75 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7400 | 3.67063 | 0.281484 | 344 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 75 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7400 | 3.67063 | 0.281484 | 343 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 75 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7400 | 3.67063 | 0.281484 | 342 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 74 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7700 | 3.81944 | 0.303087 | 331 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 74 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7700 | 3.81944 | 0.303087 | 330 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 74 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7700 | 3.81944 | 0.303087 | 329 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 74 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7700 | 3.81944 | 0.303087 | 328 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 74 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7700 | 3.81944 | 0.303087 | 327 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 73 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 8000 | 3.96825 | 0.325451 | 316 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 117 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 269 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 83 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 459 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 83 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 458 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 82 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 449 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 82 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 448 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 82 | 350 | 300 | 952.577 | 1.23835 | L_Zuluft | 5.94408 | 1300 | 3.43915 | 0.441182 | 447 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 116 | 350 | 300 | 997.995 | 1.29739 | L_Zuluft | 6.22749 | 1300 | 3.43915 | 0.462217 | 252 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 115 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1625 | 3.68481 | 0.715196 | 237 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 116 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 249 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 116 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 250 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 116 | 300 | 350 | 1473.76 | 1.91589 | L_Zuluft | 9.19626 | 1300 | 3.43915 | 0.682565 | 251 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1000 | 2.2 | L_Aussenluft | 14.08 | 4120 | 3.81481 | 0.295303 | 602 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1500 | 3.15 | L_Aussenluft | 20.16 | 3520 | 3.6214 | 0.432095 | 150 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 114 | 350 | 400 | 1500 | 2.25 | L_Zuluft | 10.8 | 1950 | 3.86905 | 0.723187 | 219 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 113 | 400 | 400 | 1500 | 2.4 | L_Zuluft | 11.52 | 2275 | 3.94965 | 0.690411 | 204 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 114 | 400 | 350 | 1500 | 2.25 | L_Zuluft | 10.8 | 1950 | 3.86905 | 0.723187 | 216 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 114 | 400 | 350 | 1500 | 2.25 | L_Zuluft | 10.8 | 1950 | 3.86905 | 0.723187 | 217 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 114 | 400 | 350 | 1200 | 1.8 | L_Zuluft | 8.64 | 1950 | 3.86905 | 0.578549 | 218 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 113 | 400 | 400 | 1500 | 2.4 | L_Zuluft | 11.52 | 2275 | 3.94965 | 0.690411 | 202 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 113 | 400 | 400 | 1200 | 1.92 | L_Zuluft | 9.216 | 2275 | 3.94965 | 0.552328 | 203 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 109 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7550 | 5.24306 | 0.69277 | 137 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 113 | 400 | 400 | 1202.8 | 1.92449 | L_Zuluft | 9.23754 | 2275 | 3.94965 | 0.55362 | 201 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 111 | 500 | 700 | 1404.92 | 3.3718 | L_Zuluft | 21.5795 | 6900 | 5.47619 | 0.751334 | 171 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 107 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8200 | 4.74537 | 0.503953 | 110 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 107 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8200 | 4.74537 | 0.503953 | 109 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 107 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8200 | 4.74537 | 0.503953 | 108 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 107 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8200 | 4.74537 | 0.503953 | 107 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 107 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8200 | 4.74537 | 0.503953 | 106 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2000 | 1800 | 1253.37 | 9.52564 | L_Abluft | 76.2051 | 33461 | 2.58187 | 0.0398686 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2000 | 1800 | 1253.37 | 9.52564 | L_Zuluft | 76.2051 | 35186 | 2.71497 | 0.0437616 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 107 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8200 | 4.74537 | 0.503953 | 105 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 1200 | 2000 | 920.83 | 5.89331 | L_Abluft | 47.1465 | 32800 | 3.7963 | 0.0793627 | 63 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 106 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8525 | 4.93345 | 0.542013 | 96 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 106 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8525 | 4.93345 | 0.542013 | 95 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 106 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8525 | 4.93345 | 0.542013 | 94 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 106 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 8525 | 4.93345 | 0.542013 | 93 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1331.03 | 5.85654 | L_Zuluft | 46.8523 | 16525 | 4.37169 | 0.257119 | 87 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 85 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 84 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 83 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 80 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 76 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 75 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 14475 | 3.82937 | 0.226271 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1500 | 700 | 1267.51 | 5.57706 | L_Zuluft | 44.6164 | 14475 | 3.82937 | 0.191201 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1500 | 700 | 1000 | 4.4 | L_Zuluft | 35.2 | 14475 | 3.82937 | 0.150847 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 1500 | 700 | 1066.73 | 4.69361 | L_Zuluft | 37.5489 | 14475 | 3.82937 | 0.160913 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 387 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Zuluft | 69.6 | 30925 | 4.09061 | 0.155023 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 84 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 85 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 86 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 87 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 88 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 89 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1000 | 5.8 | L_Aussenluft | 46.4 | 32600 | 4.31217 | 0.114073 | 90 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 93 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 94 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 95 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 96 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 106 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 107 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 108 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 109 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1000 | 5.8 | L_Aussenluft | 46.4 | 32600 | 4.31217 | 0.114073 | 80 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 112 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 113 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 114 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 115 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 116 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 117 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 118 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 119 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 120 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 121 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 122 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 123 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 109 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7550 | 5.24306 | 0.69277 | 136 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 110 | 700 | 500 | 1000 | 2.4 | L_Zuluft | 15.36 | 7225 | 5.73413 | 0.583119 | 152 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 111 | 700 | 500 | 1000 | 2.4 | L_Zuluft | 15.36 | 6900 | 5.47619 | 0.534789 | 169 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 111 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 6900 | 5.47619 | 0.802184 | 166 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 110 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 7225 | 5.73413 | 0.874678 | 156 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 590 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 589 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 588 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 1500 | 3.3 | L_Aussenluft | 21.12 | 4120 | 3.81481 | 0.442955 | 575 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 600 | 500 | 910.948 | 2.00409 | L_Aussenluft | 12.8262 | 4120 | 3.81481 | 0.269006 | 574 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 600 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 600 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 600 | 1072.23 | 2.3589 | L_Fortluft | 15.097 | 4120 | 3.81481 | 0.316633 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 1500 | 3.3 | L_Fortluft | 21.12 | 4120 | 3.81481 | 0.442955 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 500 | 949.749 | 2.08945 | L_Fortluft | 13.3725 | 4120 | 3.81481 | 0.280464 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1000 | 5.8 | L_Fortluft | 46.4 | 32600 | 4.31217 | 0.114073 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1400 | 1000 | 1500 | 7.2 | L_Fortluft | 57.6 | 16300 | 3.23413 | 0.129724 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 1400 | 1000 | 1078.67 | 5.1776 | L_Fortluft | 41.4208 | 16300 | 3.23413 | 0.0932858 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 923 | 3460 | 1398.66 | 12.2607 | L_Fortluft | 107.894 | 16300 | 1.41777 | 0.0202681 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 923 | 3460 | 1398.66 | 12.2607 | L_Fortluft | 107.894 | 16300 | 1.41777 | 0.0202681 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1500 | 1400 | 1500 | 8.7 | L_Fortluft | 69.6 | 32600 | 4.31217 | 0.17111 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1400 | 1000 | 1451.06 | 6.96509 | L_Fortluft | 55.7207 | 16300 | 3.23413 | 0.125491 | 44 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 1400 | 1000 | 1000 | 4.8 | L_Fortluft | 38.4 | 16300 | 3.23413 | 0.0864825 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1000 | 3.6 | L_Fortluft | 23.04 | 10190 | 3.49451 | 0.136596 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1069.72 | 3.851 | L_Fortluft | 24.6464 | 10190 | 3.49451 | 0.14612 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1058.88 | 3.81198 | L_Fortluft | 24.3967 | 10190 | 3.49451 | 0.144639 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 48 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 173 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 997.995 | 1.29739 | L_Zuluft | 6.22749 | 1300 | 3.43915 | 0.462217 | 162 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 48 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 169 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 48 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 170 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 48 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 171 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 48 | 300 | 250 | 935.129 | 1.02864 | L_Zuluft | 4.93748 | 975 | 3.61111 | 0.584265 | 172 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 161 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 46 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1625 | 3.68481 | 0.715196 | 145 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1300 | 3.43915 | 0.694718 | 157 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 46 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1625 | 3.68481 | 0.715196 | 144 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 46 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1625 | 3.68481 | 0.715196 | 143 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 46 | 350 | 350 | 1000 | 1.4 | L_Zuluft | 6.72 | 1625 | 3.68481 | 0.476797 | 142 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 44 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 6250 | 4.34028 | 0.486401 | 119 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 44 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 6250 | 4.34028 | 0.486401 | 118 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 44 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 6250 | 4.34028 | 0.486401 | 117 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6575 | 3.80498 | 0.33371 | 104 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 44 | 800 | 500 | 1391.02 | 3.61664 | L_Zuluft | 23.1465 | 6250 | 4.34028 | 0.451061 | 116 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6575 | 3.80498 | 0.33371 | 103 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6575 | 3.80498 | 0.33371 | 102 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6575 | 3.80498 | 0.33371 | 101 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 42 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6900 | 3.99306 | 0.365075 | 90 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 42 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6900 | 3.99306 | 0.365075 | 89 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 42 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6900 | 3.99306 | 0.365075 | 88 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 42 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6900 | 3.99306 | 0.365075 | 87 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 42 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6900 | 3.99306 | 0.365075 | 86 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1007.48 | 1.30973 | L_Zuluft | 6.2867 | 1300 | 3.43915 | 0.466612 | 160 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 41 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7225 | 4.18113 | 0.397785 | 72 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 41 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7225 | 4.18113 | 0.397785 | 71 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 41 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7225 | 4.18113 | 0.397785 | 70 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 41 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7225 | 4.18113 | 0.397785 | 69 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1500 | 8.7 | L_Aussenluft | 69.6 | 32600 | 4.31217 | 0.17111 | 125 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 932.815 | 5.41033 | L_Aussenluft | 43.2826 | 32600 | 4.31217 | 0.106409 | 124 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 21 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 1075 | 3.98148 | 1.12292 | 320 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 20 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1400 | 3.7037 | 0.796794 | 308 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 21 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 1075 | 3.98148 | 1.12292 | 315 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 21 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 1075 | 3.98148 | 1.12292 | 316 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 21 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 1075 | 3.98148 | 1.12292 | 318 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 21 | 300 | 250 | 1453.35 | 1.59869 | L_Zuluft | 7.67369 | 1075 | 3.98148 | 1.08799 | 319 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 20 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1400 | 3.7037 | 0.796794 | 307 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 20 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1400 | 3.7037 | 0.796794 | 306 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 20 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1400 | 3.7037 | 0.796794 | 305 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 20 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1400 | 3.7037 | 0.796794 | 304 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1725 | 3.91156 | 0.798939 | 290 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 20 | 350 | 300 | 1000 | 1.3 | L_Zuluft | 6.24 | 1400 | 3.7037 | 0.531196 | 303 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1725 | 3.91156 | 0.798939 | 289 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1725 | 3.91156 | 0.798939 | 288 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1725 | 3.91156 | 0.798939 | 287 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 350 | 350 | 1500 | 2.1 | L_Zuluft | 10.08 | 1725 | 3.91156 | 0.798939 | 286 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 18 | 350 | 400 | 1500 | 2.25 | L_Zuluft | 10.8 | 2050 | 4.06746 | 0.793611 | 275 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 19 | 350 | 350 | 1200 | 1.68 | L_Zuluft | 8.064 | 1725 | 3.91156 | 0.639151 | 285 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 18 | 400 | 350 | 995.741 | 1.49361 | L_Zuluft | 7.16933 | 2050 | 4.06746 | 0.526821 | 274 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6350 | 3.67477 | 0.312784 | 262 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 16 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6675 | 3.86285 | 0.343217 | 256 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 16 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6675 | 3.86285 | 0.343217 | 255 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 16 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6675 | 3.86285 | 0.343217 | 254 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 16 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 6675 | 3.86285 | 0.343217 | 253 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 15 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7000 | 4.05093 | 0.374997 | 247 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 15 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7000 | 4.05093 | 0.374997 | 246 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 15 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7000 | 4.05093 | 0.374997 | 245 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 14 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7325 | 3.63343 | 0.276203 | 234 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 15 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7000 | 4.05093 | 0.374997 | 244 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 15 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7000 | 4.05093 | 0.374997 | 243 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 15 | 600 | 800 | 1500 | 4.2 | L_Zuluft | 26.88 | 7000 | 4.05093 | 0.374997 | 242 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 14 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7325 | 3.63343 | 0.276203 | 233 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 14 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7325 | 3.63343 | 0.276203 | 232 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 14 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7325 | 3.63343 | 0.276203 | 231 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 13 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7650 | 3.79464 | 0.299433 | 225 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 13 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7650 | 3.79464 | 0.299433 | 224 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 13 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7650 | 3.79464 | 0.299433 | 223 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 13 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7650 | 3.79464 | 0.299433 | 222 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 12 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7950 | 3.94345 | 0.32167 | 216 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 12 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7950 | 3.94345 | 0.32167 | 215 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 12 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7950 | 3.94345 | 0.32167 | 214 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 12 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7950 | 3.94345 | 0.32167 | 213 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 11 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 8250 | 4.09226 | 0.344668 | 207 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 39 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7875 | 3.90625 | 0.31604 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 39 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7875 | 3.90625 | 0.31604 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 39 | 700 | 800 | 1409.89 | 4.22967 | L_Zuluft | 27.0699 | 7875 | 3.90625 | 0.297054 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1154.3 | 2.07774 | L_Fortluft | 9.97315 | 2530 | 3.51389 | 0.375899 | 369 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1004.3 | 2.0086 | L_Fortluft | 9.64128 | 3300 | 3.66667 | 0.306413 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1015.25 | 2.0305 | L_Fortluft | 9.74641 | 3300 | 3.66667 | 0.309754 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1028.42 | 1.85115 | L_Fortluft | 8.88551 | 2530 | 3.51389 | 0.334905 | 392 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1069.3 | 2.1386 | L_Aussenluft | 10.2653 | 3300 | 3.66667 | 0.326244 | 266 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1000 | 1.8 | L_Aussenluft | 8.64 | 2530 | 3.51389 | 0.325651 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1028.42 | 1.85115 | L_Aussenluft | 8.88551 | 2530 | 3.51389 | 0.334905 | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 40 | 800 | 700 | 1500 | 4.5 | L_Zuluft | 28.8 | 7550 | 3.74504 | 0.29219 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 38 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 8200 | 4.06746 | 0.340782 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 39 | 700 | 800 | 1500 | 4.5 | L_Zuluft | 28.8 | 7875 | 3.90625 | 0.31604 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
