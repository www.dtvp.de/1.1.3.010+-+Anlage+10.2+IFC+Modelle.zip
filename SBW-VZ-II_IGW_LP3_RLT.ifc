Properties of the parts of a building model (IFC2X3), part 1 of 18

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2026-07-17T11:16:57+02:00
Author: Bra
Organization: IGW
Written by: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)
Made in: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)

# IfcSite: Projektstandort, Default
RefLatitude: 49, 0, 3571; RefLongitude: 12, 15, -2; RefElevation: 0 m

# IfcSite: Pyramidenstumpf (4)
Description: Pyramidenstumpf
Pset_Basis - Name: Pyramidenstumpf; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Floor | Floor No.
2 x Pyramidenstumpf | Wartung_FFB | 2
2 x Pyramidenstumpf | EG_Verwaltung_FFB | 0

# IfcBuilding: Gebäude, Speiseverteilzentrum SBW VZ II
Description: Speiseverteilzentrum SBW VZ II

# IfcBuildingStorey: Geschoss (4)
In: Speiseverteilzentrum SBW VZ II
Name | Description | Elevation (m)
Wartung_FFB | 2 | 7.1307
UK Thermische Hülle | 1 | 6.2307
EG_Verwaltung_FFB | 0 | 0.115653
Grundleitungsebene | -1 | -1.884

# IfcBuildingElementProxy: IfcProxy (254)
Description: IfcProxy
Name | In
24 x IfcProxy | Wartung_FFB
230 x IfcProxy | EG_Verwaltung_FFB

# IfcBuildingElementProxy: Revisionswolke
In: EG_Verwaltung_FFB
Description: Revisionswolke

# IfcDistributionElement: Zylinder (16)
In: EG_Verwaltung_FFB
Description: Zylinder
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Zylinder; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcEnergyConversionDevice: Umformer, Lufterwärmer (14)
In: Wartung_FFB
Description: Umformer, Lufterwärmer
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Medium: L_Aussenluft; Calc-Zeta: 2; Name: Umformer, Lufterwärmer; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Umformer, Lufterwärmer | 93 | 1530 | 918 | 800 | 4.87367 | 872
Umformer, Lufterwärmer | 93 | 1530 | 918 | 807 | 4.87367 | 873
Umformer, Lufterwärmer | 28 | 918 | 612 | 840 | 3.1946 | 253
Umformer, Lufterwärmer | 28 | 918 | 612 | 843 | 3.1946 | 254
Umformer, Lufterwärmer | 1 | 612 | 612 | 727 | 4.22485 | 2
Umformer, Lufterwärmer | 1 | 612 | 612 | 727 | 4.22485 | 3
Umformer, Lufterwärmer | 17 | 918 | 612 | 727 | 3.63474 | 117
Umformer, Lufterwärmer | 17 | 918 | 612 | 727 | 3.63474 | 118
Umformer, Lufterwärmer | 53 | 918 | 612 | 727 | 4.97946 | 564
Umformer, Lufterwärmer | 53 | 918 | 612 | 727 | 4.97946 | 565
Umformer, Lufterwärmer | 193 | 2448 | 2448 | 1224 | 5.43195 | 644
Umformer, Lufterwärmer | 193 | 2448 | 2448 | 1607 | 5.43195 | 645
Umformer, Lufterwärmer | 8 | 2142 | 2448 | 1224 | 3.5789 | 71
Umformer, Lufterwärmer | 8 | 2142 | 2448 | 1224 | 3.5789 | 72

# IfcFlowController: Brandschutzklappe rund (14)
In: EG_Verwaltung_FFB
Description: Brandschutzklappe rund
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 400 mm; Calc-Zeta: 2; Name: Brandschutzklappe rund; Abbreviation: BSK; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Diameter (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Brandschutzklappe rund | 38 | 200 | L_Abluft | 17.3466 | 228
Brandschutzklappe rund | 48 | 100 | L_Abluft | 2.40169 | 234
Brandschutzklappe rund | 38 | 100 | L_Zuluft | 2.40169 | 255
Brandschutzklappe rund | 46 | 100 | L_Abluft | 2.40169 | 267
Brandschutzklappe rund | 36 | 100 | L_Zuluft | 2.40169 | 289
Brandschutzklappe rund | 43 | 100 | L_Abluft | 2.40169 | 317
Brandschutzklappe rund | 34 | 100 | L_Zuluft | 2.40169 | 323
Brandschutzklappe rund | 39 | 140 | L_Zuluft | 17.2315 | 242
Brandschutzklappe rund | 47 | 140 | L_Abluft | 17.2315 | 251
Brandschutzklappe rund | 35 | 100 | L_Zuluft | 2.40169 | 307
Brandschutzklappe rund | 44 | 100 | L_Abluft | 2.40169 | 300
Brandschutzklappe rund | 37 | 125 | L_Abluft | 8.85358 | 343
Brandschutzklappe rund | 27 | 125 | L_Zuluft | 8.85358 | 363
Brandschutzklappe rund | 29 | 200 | L_Zuluft | 17.3466 | 237

# IfcFlowController: Jalousieklappe (8)
In: Wartung_FFB
Description: Jalousieklappe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 125 mm; Calc-Zeta: 2; Name: Jalousieklappe; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Jalousieklappe | 93 | 918 | 1530 | L_Aussenluft | 4.87367 | 880
Jalousieklappe | 1 | 918 | 1530 | L_Fortluft | 4.87367 | 3
Jalousieklappe | 28 | 612 | 918 | L_Aussenluft | 3.1946 | 261
Jalousieklappe | 1 | 612 | 918 | L_Fortluft | 3.1946 | 3
Jalousieklappe | 1 | 612 | 612 | L_Aussenluft | 4.22485 | 10
Jalousieklappe | 30 | 612 | 612 | L_Fortluft | 4.22485 | 363
Jalousieklappe | 17 | 612 | 918 | L_Aussenluft | 3.63474 | 125
Jalousieklappe | 1 | 612 | 918 | L_Fortluft | 3.63474 | 3

# IfcFlowController: Rückschlagklappe rund
In: EG_Verwaltung_FFB
Description: Rückschlagklappe rund
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 1; Geom-Diameter (mm): 200 mm; Geom-Length (mm): 140 mm; Tech-Medium: L_Fortluft; Calc-Zeta: 2; Calc-Pressure loss (Pa): 20 Pa; Name: Rückschlagklappe rund; Pos. No.: 5; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowController: Volumenstromregler Rechteck (14)
In: Wartung_FFB
Description: Volumenstromregler Rechteck
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 500 mm; Calc-Zeta: 2; Name: Volumenstromregler Rechteck; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Side 1 (mm) (mm) = Geom-Connection height (mm) (mm) | Geom-Side 2 (mm) (mm) = Geom-Connection width (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Volumenstromregler Rechteck | 171 | 700 | 500 | L_Zuluft | 16.8393 | 307
Volumenstromregler Rechteck | 4 | 700 | 500 | L_Abluft | 18.6028 | 454
Volumenstromregler Rechteck | 33 | 1300 | 1400 | L_Zuluft | 12.2208 | 21
Volumenstromregler Rechteck | 53 | 500 | 800 | L_Abluft | 16.875 | 182
Volumenstromregler Rechteck | 61 | 400 | 700 | L_Abluft | 15.3061 | 131
Volumenstromregler Rechteck | 69 | 500 | 800 | L_Abluft | 16.875 | 78
Volumenstromregler Rechteck | 7 | 300 | 350 | L_Zuluft | 15.3061 | 584
Volumenstromregler Rechteck | 18 | 350 | 500 | L_Zuluft | 14.66 | 525
Volumenstromregler Rechteck | 35 | 400 | 800 | L_Abluft | 18.3105 | 310
Volumenstromregler Rechteck | 43 | 300 | 550 | L_Abluft | 16.4609 | 273
Volumenstromregler Rechteck | 47 | 350 | 300 | L_Abluft | 15.3061 | 238
Volumenstromregler Rechteck | 69 | 500 | 300 | L_Abluft | 16.4609 | 78
Volumenstromregler Rechteck | 17 | 600 | 500 | L_Zuluft | 14.4676 | 375
Volumenstromregler Rechteck | 17 | 600 | 500 | L_Abluft | 16.875 | 375

# IfcFlowController: Volumenstromregler Rund (286)
Description: Volumenstromregler Rund
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Connection length (mm): 50 mm; Calc-Zeta: 2; Name: Volumenstromregler Rund; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Section No | Geom-Diameter (mm) (mm) = Geom-Housing diameter (mm) (mm) | Geom-Housing length (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No.
Volumenstromregler Rund | Wartung_FFB | 1 | 400 | 500 | L_Abluft | 150 | 3 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 85 | 160 | 320 | L_Zuluft | 100 | 483 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 86 | 160 | 320 | L_Zuluft | 100 | 474 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 87 | 160 | 320 | L_Zuluft | 100 | 466 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 88 | 160 | 320 | L_Zuluft | 100 | 453 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 89 | 160 | 320 | L_Zuluft | 100 | 438 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 143 | 160 | 320 | L_Zuluft | 100 | 102 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 142 | 160 | 320 | L_Zuluft | 100 | 116 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 136 | 160 | 320 | L_Zuluft | 100 | 161 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 134 | 160 | 320 | L_Zuluft | 100 | 179 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 131 | 160 | 320 | L_Zuluft | 100 | 210 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 129 | 160 | 320 | L_Zuluft | 100 | 225 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 123 | 160 | 320 | L_Zuluft | 100 | 272 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 121 | 160 | 320 | L_Zuluft | 100 | 289 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 119 | 160 | 320 | L_Zuluft | 100 | 307 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 50 | 160 | 320 | L_Zuluft | 100 | 193 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 51 | 160 | 320 | L_Zuluft | 100 | 184 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 52 | 160 | 320 | L_Zuluft | 100 | 176 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 53 | 160 | 320 | L_Zuluft | 100 | 165 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 54 | 160 | 320 | L_Zuluft | 100 | 151 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 69 | 160 | 320 | L_Zuluft | 100 | 25 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 91 | 630 | 500 | L_Zuluft | 17.6186 | 422 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 133 | 630 | 500 | L_Zuluft | 17.6186 | 195 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 56 | 630 | 500 | L_Zuluft | 17.6186 | 135 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 57 | 160 | 320 | L_Zuluft | 100 | 125 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 59 | 160 | 320 | L_Zuluft | 100 | 110 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 61 | 160 | 320 | L_Zuluft | 100 | 96 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 63 | 160 | 320 | L_Zuluft | 100 | 81 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 31 | 630 | 500 | L_Zuluft | 17.6186 | 268 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 37 | 160 | 320 | L_Zuluft | 100 | 210 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 36 | 160 | 320 | L_Zuluft | 100 | 219 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 29 | 160 | 320 | L_Zuluft | 100 | 296 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 30 | 160 | 320 | L_Zuluft | 100 | 281 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 32 | 160 | 320 | L_Zuluft | 100 | 259 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 33 | 160 | 320 | L_Zuluft | 100 | 250 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 34 | 160 | 320 | L_Zuluft | 100 | 237 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 35 | 160 | 320 | L_Zuluft | 100 | 228 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 27 | 160 | 320 | L_Zuluft | 100 | 323 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 28 | 160 | 320 | L_Zuluft | 100 | 311 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 23 | 160 | 320 | L_Zuluft | 100 | 344 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 25 | 160 | 320 | L_Zuluft | 100 | 333 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 138 | 160 | 320 | L_Zuluft | 100 | 143 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 104 | 160 | 320 | L_Zuluft | 100 | 322 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 102 | 160 | 320 | L_Zuluft | 100 | 337 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 100 | 160 | 320 | L_Zuluft | 100 | 351 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 98 | 160 | 320 | L_Zuluft | 100 | 368 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 96 | 160 | 320 | L_Zuluft | 100 | 382 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 94 | 160 | 320 | L_Zuluft | 100 | 397 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 92 | 160 | 320 | L_Zuluft | 100 | 412 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 52 | 100 | 320 | L_Abluft | 100 | 145 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 47 | 100 | 320 | L_Zuluft | 100 | 113 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 50 | 100 | 320 | L_Zuluft | 100 | 84 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 55 | 100 | 320 | L_Abluft | 100 | 114 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 56 | 100 | 320 | L_Abluft | 100 | 93 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 51 | 100 | 320 | L_Zuluft | 100 | 61 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 57 | 100 | 320 | L_Abluft | 100 | 66 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 52 | 100 | 320 | L_Zuluft | 100 | 31 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 140 | 160 | 320 | L_Zuluft | 100 | 129 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 127 | 160 | 320 | L_Zuluft | 100 | 239 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 125 | 160 | 320 | L_Zuluft | 100 | 254 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 65 | 160 | 320 | L_Zuluft | 100 | 62 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 67 | 160 | 320 | L_Zuluft | 100 | 48 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 51 | 100 | 320 | L_Abluft | 100 | 176 | Wartung_FFB | 2
Volumenstromregler Rund | Wartung_FFB | 46 | 100 | 320 | L_Zuluft | 100 | 142 | Wartung_FFB | 2
Volumenstromregler Rund | EG_Verwaltung_FFB | 39 | 160 | 320 | L_Abluft | 100 | 697 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 37 | 160 | 320 | L_Zuluft | 100 | 642 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 40 | 100 | 320 | L_Abluft | 100 | 677 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 53 | 125 | 320 | L_Zuluft | 100 | 439 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 56 | 125 | 320 | L_Abluft | 100 | 461 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 38 | 100 | 320 | L_Zuluft | 100 | 620 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 47 | 100 | 320 | L_Zuluft | 100 | 554 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 48 | 100 | 320 | L_Abluft | 100 | 606 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 35 | 140 | 320 | L_Zuluft | 100 | 677 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 37 | 140 | 320 | L_Abluft | 100 | 730 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 32 | 125 | 320 | L_Zuluft | 100 | 725 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 33 | 125 | 320 | L_Abluft | 100 | 779 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 30 | 125 | 320 | L_Zuluft | 100 | 762 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 32 | 125 | 320 | L_Abluft | 100 | 797 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 34 | 140 | 320 | L_Zuluft | 100 | 695 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 36 | 140 | 320 | L_Abluft | 100 | 743 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 31 | 140 | 320 | L_Zuluft | 100 | 741 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 34 | 140 | 320 | L_Abluft | 100 | 767 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 48 | 100 | 320 | L_Zuluft | 100 | 534 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 50 | 100 | 320 | L_Abluft | 100 | 574 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 38 | 125 | 320 | L_Abluft | 100 | 713 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 41 | 160 | 320 | L_Zuluft | 100 | 587 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 42 | 160 | 320 | L_Abluft | 100 | 639 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 39 | 160 | 320 | L_Zuluft | 100 | 610 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 41 | 160 | 320 | L_Abluft | 100 | 660 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 55 | 100 | 320 | L_Abluft | 100 | 477 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 53 | 100 | 320 | L_Abluft | 100 | 511 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 52 | 100 | 320 | L_Zuluft | 100 | 461 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 36 | 125 | 320 | L_Zuluft | 100 | 658 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 43 | 125 | 320 | L_Abluft | 100 | 625 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 42 | 125 | 320 | L_Zuluft | 100 | 575 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 100 | 320 | L_Abluft | 100 | 868 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 100 | 320 | L_Zuluft | 100 | 831 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 125 | 320 | L_Zuluft | 100 | 862 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 125 | 320 | L_Abluft | 100 | 908 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 140 | 320 | L_Zuluft | 100 | 816 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 140 | 320 | L_Abluft | 100 | 851 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 140 | 320 | L_Abluft | 100 | 886 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 65 | 125 | 320 | L_Zuluft | 100 | 335 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 88 | 125 | 320 | L_Abluft | 100 | 141 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 63 | 100 | 320 | L_Zuluft | 100 | 346 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 90 | 100 | 320 | L_Abluft | 100 | 122 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 91 | 100 | 320 | L_Abluft | 100 | 108 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 68 | 100 | 320 | L_Zuluft | 100 | 300 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 67 | 100 | 320 | L_Zuluft | 100 | 318 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 87 | 100 | 320 | L_Abluft | 100 | 156 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 85 | 180 | 320 | L_Zuluft | 100 | 158 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 76 | 180 | 320 | L_Abluft | 100 | 284 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 80 | 125 | 320 | L_Abluft | 100 | 219 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 89 | 125 | 320 | L_Zuluft | 100 | 94 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 78 | 140 | 320 | L_Abluft | 100 | 251 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 87 | 140 | 320 | L_Zuluft | 100 | 125 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 75 | 160 | 320 | L_Abluft | 100 | 299 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 84 | 160 | 320 | L_Zuluft | 100 | 173 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 73 | 125 | 320 | L_Abluft | 100 | 330 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 83 | 125 | 320 | L_Zuluft | 100 | 189 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 74 | 160 | 320 | L_Abluft | 100 | 315 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 82 | 160 | 320 | L_Zuluft | 100 | 203 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 70 | 200 | 320 | L_Abluft | 100 | 377 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 81 | 200 | 320 | L_Zuluft | 100 | 221 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 79 | 200 | 320 | L_Zuluft | 100 | 251 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 72 | 200 | 320 | L_Abluft | 100 | 347 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 71 | 200 | 320 | L_Abluft | 100 | 364 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 80 | 200 | 320 | L_Zuluft | 100 | 237 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 86 | 140 | 320 | L_Zuluft | 100 | 138 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 77 | 140 | 320 | L_Abluft | 100 | 264 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 88 | 140 | 320 | L_Zuluft | 100 | 107 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 79 | 140 | 320 | L_Abluft | 100 | 233 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 82 | 160 | 320 | L_Abluft | 100 | 188 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 92 | 160 | 320 | L_Zuluft | 100 | 46 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 93 | 160 | 320 | L_Abluft | 100 | 71 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 69 | 160 | 320 | L_Zuluft | 100 | 279 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 92 | 160 | 320 | L_Abluft | 100 | 82 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 70 | 160 | 320 | L_Zuluft | 100 | 268 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 83 | 160 | 320 | L_Abluft | 100 | 173 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 91 | 160 | 320 | L_Zuluft | 100 | 59 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 81 | 125 | 320 | L_Abluft | 100 | 202 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 90 | 125 | 320 | L_Zuluft | 100 | 75 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 200 | 320 | L_Zuluft | 100 | 793 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 200 | 320 | L_Abluft | 100 | 826 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 200 | 320 | L_Abluft | 100 | 836 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 57 | 200 | 320 | L_Abluft | 100 | 441 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 58 | 200 | 320 | L_Abluft | 100 | 432 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 57 | 200 | 320 | L_Zuluft | 100 | 400 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 58 | 200 | 320 | L_Zuluft | 100 | 392 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 55 | 200 | 320 | L_Zuluft | 100 | 410 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 33 | 125 | 320 | L_Zuluft | 100 | 713 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 54 | 100 | 320 | L_Abluft | 100 | 495 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 49 | 100 | 320 | L_Abluft | 100 | 590 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 22 | 140 | 320 | L_Abluft | 100 | 563 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 140 | 320 | L_Zuluft | 100 | 531 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 140 | 320 | L_Zuluft | 100 | 547 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 140 | 320 | L_Zuluft | 100 | 558 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 24 | 140 | 320 | L_Abluft | 100 | 532 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 23 | 140 | 320 | L_Abluft | 100 | 548 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 25 | 140 | 320 | L_Abluft | 100 | 499 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 26 | 140 | 320 | L_Abluft | 100 | 480 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 140 | 320 | L_Zuluft | 100 | 501 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 20 | 140 | 320 | L_Zuluft | 100 | 446 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 29 | 140 | 320 | L_Abluft | 100 | 441 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 19 | 140 | 320 | L_Zuluft | 100 | 461 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 18 | 140 | 320 | L_Zuluft | 100 | 484 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 28 | 140 | 320 | L_Abluft | 100 | 465 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 30 | 200 | 320 | L_Abluft | 100 | 419 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 21 | 200 | 320 | L_Zuluft | 100 | 417 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 34 | 140 | 320 | L_Abluft | 100 | 363 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 40 | 140 | 320 | L_Zuluft | 100 | 215 | EG_Verwaltung_FFB | 0
3 x Volumenstromregler Rund | EG_Verwaltung_FFB |  | 125 | 320 | L_Zuluft | 100 |  | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 125 | 320 | L_Abluft | 100 | 580 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 27 | 125 | 320 | L_Zuluft | 100 | 369 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 37 | 125 | 320 | L_Abluft | 100 | 349 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 28 | 140 | 320 | L_Zuluft | 100 | 349 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 39 | 140 | 320 | L_Zuluft | 100 | 244 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 47 | 140 | 320 | L_Abluft | 100 | 254 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 49 | 140 | 320 | L_Abluft | 100 | 214 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 48 | 100 | 320 | L_Abluft | 100 | 236 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 38 | 100 | 320 | L_Zuluft | 100 | 257 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 46 | 100 | 320 | L_Abluft | 100 | 269 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 36 | 100 | 320 | L_Zuluft | 100 | 291 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 125 | 320 | L_Abluft | 100 | 598 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 125 | 320 | L_Abluft | 100 | 613 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 16 | 200 | 320 | L_Abluft | 100 | 51 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 200 | 320 | L_Abluft | 100 | 66 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 200 | 320 | L_Abluft | 100 | 76 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 200 | 320 | L_Zuluft | 100 | 31 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 16 | 200 | 320 | L_Zuluft | 100 | 16 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 200 | 320 | L_Zuluft | 100 | 45 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 200 | 320 | L_Zuluft | 100 | 59 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 200 | 320 | L_Zuluft | 100 | 74 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 9 | 200 | 320 | L_Zuluft | 100 | 112 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 200 | 320 | L_Zuluft | 100 | 100 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 200 | 320 | L_Zuluft | 100 | 90 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 200 | 320 | L_Abluft | 100 | 122 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 200 | 320 | L_Abluft | 100 | 97 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 200 | 320 | L_Abluft | 100 | 138 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 9 | 200 | 320 | L_Abluft | 100 | 148 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 200 | 320 | L_Abluft | 100 | 106 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 16 | 125 | 320 | L_Abluft | 100 | 230 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 125 | 320 | L_Zuluft | 100 | 272 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 16 | 125 | 320 | L_Zuluft | 100 | 254 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 17 | 125 | 320 | L_Abluft | 100 | 215 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 19 | 125 | 320 | L_Zuluft | 100 | 199 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 20 | 125 | 320 | L_Abluft | 100 | 162 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 18 | 125 | 320 | L_Zuluft | 100 | 218 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 19 | 125 | 320 | L_Abluft | 100 | 181 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 100 | 320 | L_Abluft | 100 | 247 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 125 | 320 | L_Abluft | 100 | 260 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 160 | 320 | L_Zuluft | 100 | 288 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 9 | 180 | 320 | L_Zuluft | 100 | 361 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 8 | 180 | 320 | L_Zuluft | 100 | 373 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 7 | 180 | 320 | L_Abluft | 100 | 351 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 8 | 180 | 320 | L_Abluft | 100 | 343 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 100 | 320 | L_Zuluft | 100 | 345 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 27 | 100 | 320 | L_Abluft | 100 | 90 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 25 | 100 | 320 | L_Zuluft | 100 | 152 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 29 | 160 | 320 | L_Abluft | 100 | 60 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 28 | 160 | 320 | L_Abluft | 100 | 76 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 26 | 125 | 320 | L_Abluft | 100 | 109 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 24 | 125 | 320 | L_Zuluft | 100 | 171 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 26 | 160 | 320 | L_Zuluft | 100 | 135 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 27 | 160 | 320 | L_Zuluft | 100 | 115 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 22 | 160 | 320 | L_Abluft | 100 | 137 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 28 | 160 | 320 | L_Zuluft | 100 | 100 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 6 | 160 | 320 | L_Zuluft | 100 | 223 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 5 | 160 | 320 | L_Zuluft | 100 | 247 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 7 | 160 | 320 | L_Abluft | 100 | 279 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 160 | 320 | L_Zuluft | 100 | 210 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 160 | 320 | L_Abluft | 100 | 263 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 6 | 160 | 320 | L_Abluft | 100 | 299 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 160 | 320 | L_Abluft | 100 | 255 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 160 | 320 | L_Zuluft | 100 | 200 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 12 | 160 | 320 | L_Zuluft | 100 | 185 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 14 | 160 | 320 | L_Abluft | 100 | 214 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 100 | 320 | L_Zuluft | 100 | 165 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 13 | 100 | 320 | L_Abluft | 100 | 234 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 43 | 100 | 320 | L_Abluft | 100 | 319 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 34 | 100 | 320 | L_Zuluft | 100 | 325 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 44 | 100 | 320 | L_Abluft | 100 | 303 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 35 | 100 | 320 | L_Zuluft | 100 | 309 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 45 | 100 | 320 | L_Abluft | 100 | 285 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 37 | 100 | 320 | L_Zuluft | 100 | 276 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 26 | 160 | 320 | L_Zuluft | 100 | 57 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 26 | 160 | 320 | L_Abluft | 100 | 118 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 25 | 160 | 320 | L_Zuluft | 100 | 68 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 27 | 160 | 320 | L_Abluft | 100 | 107 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 21 | 160 | 320 | L_Zuluft | 100 | 115 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 27 | 160 | 320 | L_Zuluft | 100 | 39 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 20 | 160 | 320 | L_Zuluft | 100 | 128 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 21 | 160 | 320 | L_Abluft | 100 | 182 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 19 | 160 | 320 | L_Zuluft | 100 | 141 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 22 | 160 | 320 | L_Abluft | 100 | 160 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 28 | 160 | 320 | L_Abluft | 100 | 85 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 23 | 160 | 320 | L_Abluft | 100 | 150 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 22 | 160 | 320 | L_Zuluft | 100 | 97 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 23 | 160 | 320 | L_Zuluft | 100 | 84 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 24 | 160 | 320 | L_Abluft | 100 | 134 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 20 | 160 | 320 | L_Abluft | 100 | 193 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 15 | 200 | 320 | L_Zuluft | 100 | 780 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 16 | 200 | 320 | L_Zuluft | 100 | 772 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 59 | 200 | 320 | L_Abluft | 100 | 423 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 16 | 200 | 320 | L_Abluft | 100 | 814 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 7 | 200 | 320 | L_Abluft | 100 | 628 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 41 | 200 | 320 | L_Zuluft | 100 | 190 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 22 | 125 | 320 | L_Zuluft | 100 | 399 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 31 | 125 | 320 | L_Abluft | 100 | 396 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 32 | 200 | 320 | L_Abluft | 100 | 380 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 23 | 200 | 320 | L_Zuluft | 100 | 388 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 100 | 320 | L_Zuluft | 100 | 330 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 9 | 100 | 320 | L_Abluft | 100 | 325 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 10 | 100 | 320 | L_Abluft | 100 | 310 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 11 | 140 | 320 | L_Zuluft | 100 | 847 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 51 | 125 | 320 | L_Zuluft | 100 | 479 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 50 | 100 | 320 | L_Zuluft | 100 | 496 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 52 | 100 | 320 | L_Abluft | 100 | 534 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 45 | 200 | 320 | L_Zuluft | 100 | 173 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 51 | 100 | 320 | L_Abluft | 100 | 554 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 49 | 100 | 320 | L_Zuluft | 100 | 515 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 5 | 400 | 400 | L_Abluft | 100 | 29 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 4 | 400 | 400 | L_Abluft | 100 | 41 | EG_Verwaltung_FFB | 0
Volumenstromregler Rund | EG_Verwaltung_FFB | 6 | 250 | 400 | L_Abluft | 100 | 21 | EG_Verwaltung_FFB | 0

# IfcFlowFitting: Abzweigstück 90° (77)
Description: Abzweigstück 90°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 90 rad; Tech-Material (ID): 1; Name: Abzweigstück 90°; Abbreviation: ATE
Name | In | Section No | Geom-Main diameter (mm) (mm) = Geom-Secondary diameter (mm) (mm) | Geom-Branch diameter (mm) (mm) | Geom-Length (mm) (mm) | Geom-Branch length (mm) (mm) | Tech-Medium | Pos. No. | Floor | Floor No. | Building = Building No.
Abzweigstück 90° | Wartung_FFB | 84 | 250 | 160 | 260 | 175 | L_Zuluft | 472 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 118 | 250 | 160 | 260 | 175 | L_Zuluft | 287 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 49 | 250 | 160 | 260 | 175 | L_Zuluft | 182 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 22 | 250 | 160 | 260 | 175 | L_Zuluft | 331 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 50 | 140 | 100 | 190 | 115 | L_Abluft | 141 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 54 | 140 | 100 | 190 | 115 | L_Abluft | 89 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 49 | 140 | 100 | 190 | 115 | L_Zuluft | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 53 | 180 | 100 | 190 | 135 | L_Abluft | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 48 | 180 | 100 | 190 | 135 | L_Zuluft | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 43 | 250 | 100 | 190 | 170 | L_Zuluft | 138 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | Wartung_FFB | 42 | 250 | 100 | 190 | 170 | L_Zuluft | 109 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 29 | 200 | 140 | 240 | 150 | L_Zuluft | 737 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 28 | 200 | 125 | 215 | 145 | L_Zuluft | 721 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 31 | 200 | 125 | 215 | 145 | L_Abluft | 775 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 30 | 200 | 140 | 240 | 150 | L_Abluft | 763 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 44 | 160 | 100 | 190 | 125 | L_Zuluft | 488 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 44 | 180 | 100 | 190 | 135 | L_Abluft | 526 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 45 | 160 | 100 | 190 | 125 | L_Zuluft | 507 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 45 | 160 | 100 | 190 | 125 | L_Abluft | 546 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 46 | 140 | 100 | 190 | 115 | L_Abluft | 566 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 46 | 125 | 100 | 190 | 110 | L_Zuluft | 528 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 9 | 180 | 140 | 240 | 140 | L_Abluft | 882 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 9 | 180 | 140 | 240 | 140 | L_Zuluft | 843 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 62 | 180 | 180 | 280 | 140 | L_Zuluft | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 89 | 125 | 100 | 190 | 110 | L_Abluft | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 85 | 180 | 125 | 215 | 135 | L_Abluft | 98 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 86 | 180 | 125 | 215 | 135 | L_Abluft | 137 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 66 | 125 | 100 | 190 | 110 | L_Zuluft | 298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 64 | 180 | 180 | 280 | 140 | L_Zuluft | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 8 | 200 | 100 | 190 | 145 | L_Zuluft | 827 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 8 | 200 | 100 | 190 | 145 | L_Abluft | 862 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 47 | 125 | 100 | 190 | 110 | L_Abluft | 588 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 43 | 180 | 125 | 215 | 135 | L_Zuluft | 473 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 11 | 200 | 140 | 240 | 150 | L_Zuluft | 541 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 21 | 200 | 140 | 240 | 150 | L_Abluft | 542 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 17 | 200 | 140 | 240 | 150 | L_Zuluft | 455 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 27 | 200 | 140 | 240 | 150 | L_Abluft | 435 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB |  | 180 | 125 | 215 | 135 | L_Zuluft |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 9 | 180 | 125 | 215 | 135 | L_Abluft | 594 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 12 | 180 | 125 | 215 | 135 | L_Abluft | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 13 | 180 | 125 | 215 | 135 | L_Zuluft | 268 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 17 | 180 | 125 | 215 | 135 | L_Zuluft | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 18 | 180 | 125 | 215 | 135 | L_Abluft | 158 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 13 | 160 | 100 | 190 | 125 | L_Abluft | 245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 25 | 160 | 100 | 190 | 125 | L_Abluft | 86 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 23 | 160 | 100 | 190 | 125 | L_Zuluft | 148 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 29 | 200 | 140 | 240 | 150 | L_Zuluft | 239 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 30 | 200 | 100 | 190 | 145 | L_Zuluft | 251 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 31 | 160 | 100 | 190 | 125 | L_Zuluft | 270 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 32 | 160 | 100 | 190 | 125 | L_Zuluft | 285 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 33 | 100 | 100 | 190 | 95 | L_Zuluft | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 38 | 200 | 100 | 190 | 145 | L_Abluft | 230 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 40 | 125 | 100 | 190 | 110 | L_Abluft | 263 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 42 | 100 | 100 | 190 | 95 | L_Abluft | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 39 | 200 | 140 | 240 | 150 | L_Abluft | 247 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 41 | 125 | 100 | 190 | 110 | L_Abluft | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 26 | 180 | 140 | 240 | 140 | L_Zuluft | 345 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 185 | 280 | 200 | 330 | 205 | L_Zuluft | 373 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 182 | 280 | 200 | 330 | 205 | L_Zuluft | 384 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 198 | 280 | 200 | 330 | 205 | L_Zuluft | 338 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 175 | 280 | 200 | 330 | 205 | L_Zuluft | 405 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 193 | 280 | 200 | 330 | 205 | L_Zuluft | 351 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Abzweigstück 90° | EG_Verwaltung_FFB | 168 | 250 | 200 | 330 | 190 | L_Zuluft | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 25 | 280 | 200 | 330 | 205 | L_Zuluft | 566 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 21 | 280 | 200 | 330 | 205 | L_Zuluft | 575 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 30 | 280 | 200 | 330 | 205 | L_Zuluft | 546 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 2 | 630 | 630 | 810 | 405 | L_Abluft | 13 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Abzweigstück 90° | EG_Verwaltung_FFB | 3 | 630 | 400 | 570 | 400 | L_Abluft | 25 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Abzweigstück 90° | EG_Verwaltung_FFB |  | 280 | 200 | 330 | 205 | L_Zuluft
Abzweigstück 90° | EG_Verwaltung_FFB |  | 280 | 280 | 430 | 215 | L_Abluft
Abzweigstück 90° | EG_Verwaltung_FFB |  | 250 | 200 | 330 | 190 | L_Zuluft

# IfcFlowFitting: Boden (4)
In: Wartung_FFB
Description: Boden
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Side 1 (mm): 1400 mm; Geom-Side 2 (mm): 500 mm; Geom-Length (mm): 50 mm; Geom-Surface (m2): 1 m2; Tech-Medium: L_Abluft; Tech-Weight (kg): 5.6 kg; Tech-Material (ID): 1; Name: Boden; Abbreviation: BO; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Pos. No.
Boden | 8 | 148
Boden | 14 | 127
Boden | 20 | 99
Boden | 26 | 88

# IfcFlowFitting: Bogen (860)
Description: Bogen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Bogen
Name | In | Section No | Geom-Diameter (mm) (mm) = Geom-Radius (mm) (mm) | Geom-Angle (°) (rad) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Abbreviation | Floor | Floor No. | Building = Building No.
Bogen | Wartung_FFB | 85 | 160 | 90 | L_Zuluft | 3.74986 | 481 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 89 | 160 | 45 | L_Zuluft | 2.32936 | 434 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 92 | 160 | 45 | L_Zuluft | 2.32936 | 408 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 94 | 160 | 45 | L_Zuluft | 2.32936 | 393 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 96 | 160 | 45 | L_Zuluft | 2.32936 | 378 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 98 | 160 | 45 | L_Zuluft | 2.32936 | 364 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 100 | 160 | 45 | L_Zuluft | 2.32936 | 347 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 102 | 160 | 45 | L_Zuluft | 2.32936 | 333 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 104 | 160 | 45 | L_Zuluft | 2.32936 | 318 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 129 | 160 | 45 | L_Zuluft | 2.73377 | 221 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 131 | 160 | 45 | L_Zuluft | 2.73377 | 206 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 134 | 160 | 90 | L_Zuluft | 3.74986 | 173 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 138 | 160 | 45 | L_Zuluft | 2.73377 | 139 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 118 | 250 | 45 | L_Zuluft | 1.8346 | 283 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 118 | 250 | 45 | L_Zuluft | 1.8346 | 285 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 119 | 160 | 45 | L_Zuluft | 2.73377 | 301 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 119 | 160 | 45 | L_Zuluft | 2.73377 | 303 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 119 | 160 | 90 | L_Zuluft | 3.74986 | 305 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 119 | 160 | 60 | L_Zuluft | 3.19101 | 311 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 50 | 160 | 90 | L_Zuluft | 3.74986 | 191 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 160 | 45 | L_Zuluft | 2.73377 | 147 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 54 | 160 | 45 | L_Zuluft | 2.73377 | 149 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 160 | 45 | L_Zuluft | 2.73377 | 121 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 57 | 160 | 45 | L_Zuluft | 2.73377 | 123 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 59 | 160 | 45 | L_Zuluft | 2.73377 | 106 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 59 | 160 | 45 | L_Zuluft | 2.73377 | 108 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 61 | 160 | 45 | L_Zuluft | 2.73377 | 94 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 63 | 160 | 45 | L_Zuluft | 2.73377 | 79 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 143 | 160 | 45 | L_Zuluft | 2.73377 | 98 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 143 | 160 | 45 | L_Zuluft | 2.73377 | 100 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 142 | 160 | 45 | L_Zuluft | 2.73377 | 112 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 142 | 160 | 45 | L_Zuluft | 2.73377 | 114 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 23 | 160 | 90 | L_Zuluft | 4.99242 | 342 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 22 | 250 | 45 | L_Zuluft | 2.44252 | 327 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 29 | 160 | 45 | L_Zuluft | 2.73377 | 292 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 29 | 160 | 45 | L_Zuluft | 2.73377 | 294 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 30 | 160 | 45 | L_Zuluft | 2.73377 | 277 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 30 | 160 | 45 | L_Zuluft | 2.73377 | 279 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 69 | 160 | 90 | L_Zuluft | 3.74986 | 21 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 69 | 160 | 90 | L_Zuluft | 3.74986 | 23 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 119 | 160 | 60 | L_Zuluft | 3.19101 | 309 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 129 | 160 | 45 | L_Zuluft | 2.73377 | 223 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 131 | 160 | 45 | L_Zuluft | 2.73377 | 208 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 134 | 160 | 60 | L_Zuluft | 3.19101 | 175 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 134 | 160 | 60 | L_Zuluft | 3.19101 | 177 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 136 | 160 | 90 | L_Zuluft | 3.74986 | 159 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 138 | 160 | 45 | L_Zuluft | 2.73377 | 141 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 104 | 160 | 45 | L_Zuluft | 2.32936 | 320 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 102 | 160 | 45 | L_Zuluft | 2.32936 | 335 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 100 | 160 | 45 | L_Zuluft | 2.32936 | 349 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 98 | 160 | 45 | L_Zuluft | 2.32936 | 366 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 96 | 160 | 45 | L_Zuluft | 2.32936 | 380 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 94 | 160 | 45 | L_Zuluft | 2.32936 | 395 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen | Wartung_FFB | 92 | 160 | 45 | L_Zuluft | 2.32936 | 410 | BGE | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
