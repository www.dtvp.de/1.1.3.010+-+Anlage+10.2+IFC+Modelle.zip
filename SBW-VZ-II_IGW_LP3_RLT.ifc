Properties of the parts of a building model (IFC2X3), part 11 of 18

# IfcFlowSegment: Luftleitung (1382)
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitung | EG_Verwaltung_FFB | 44 | 550 | 300 | 1126.03 | 1.91425 | L_Abluft | 12.2512 | 2200 | 3.7037 | 0.477155 | 289 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 46 | 400 | 200 | 1390.33 | 1.66839 | L_Abluft | 8.00829 | 1100 | 3.81944 | 0.990837 | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1003.44 | 1.00344 | L_Abluft | 4.8165 | 760 | 3.51852 | 0.700107 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 2 | 500 | 500 | 1089.2 | 2.1784 | L_Zuluft | 10.4563 | 3300 | 3.66667 | 0.332315 | 23 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 400 | 250 | 1500 | 1.95 | L_Zuluft | 9.36 | 1340 | 3.72222 | 0.854052 | 148 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 240 | 1.66667 | 0.336411 | 206 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 200 | 909.559 | 0.727648 | L_Zuluft | 3.49271 | 240 | 1.66667 | 0.20399 | 207 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 26 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 27 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 28 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 29 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 30 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 31 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 32 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 550 | 250 | 1150 | 1.84 | L_Zuluft | 11.776 | 1960 | 3.9596 | 0.640595 | 33 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 250 | 550 | 1500 | 2.4 | L_Zuluft | 15.36 | 1715 | 3.46465 | 0.652441 | 45 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 350 | 250 | 1500 | 1.8 | L_Zuluft | 8.64 | 1225 | 3.88889 | 0.989456 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 350 | 250 | 1500 | 1.8 | L_Zuluft | 8.64 | 1225 | 3.88889 | 0.989456 | 78 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 350 | 250 | 1500 | 1.8 | L_Zuluft | 8.64 | 1225 | 3.88889 | 0.989456 | 77 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 490 | 3.40278 | 1.23435 | 51 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 200 | 200 | 1232.53 | 0.986027 | L_Zuluft | 4.73293 | 490 | 3.40278 | 1.01425 | 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 200 | 250 | 1335.74 | 1.20216 | L_Zuluft | 5.77038 | 630 | 3.5 | 1.01548 | 357 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 12 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 460 | 3.19444 | 1.09887 | 245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 250 | 1335.74 | 1.20216 | L_Abluft | 5.77038 | 630 | 3.5 | 1.01548 | 339 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 61 | 650 | 500 | 1000 | 2.3 | L_Abluft | 14.72 | 4380 | 3.74359 | 0.273032 | 59 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 60 | 650 | 500 | 1000 | 2.3 | L_Zuluft | 14.72 | 4380 | 3.74359 | 0.273032 | 35 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 600 | 300 | 1500 | 2.7 | L_Zuluft | 17.28 | 2570 | 3.96605 | 0.695745 | 422 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 600 | 300 | 1000 | 1.8 | L_Zuluft | 11.52 | 2570 | 3.96605 | 0.324681 | 423 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 600 | 300 | 1500 | 2.7 | L_Zuluft | 17.28 | 2570 | 3.96605 | 0.695745 | 425 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 600 | 300 | 1500 | 2.7 | L_Zuluft | 17.28 | 2570 | 3.96605 | 0.695745 | 426 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 600 | 300 | 1500 | 2.7 | L_Zuluft | 17.28 | 2570 | 3.96605 | 0.695745 | 427 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 600 | 300 | 971.826 | 1.74929 | L_Zuluft | 11.1954 | 2570 | 3.96605 | 0.450762 | 428 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 500 | 300 | 1242.9 | 1.98864 | L_Zuluft | 9.54549 | 1900 | 3.51852 | 0.499792 | 394 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB |  | 200 | 200 | 1228.69 | 0.982956 | L_Zuluft | 4.71819 |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB |  | 200 | 200 | 1000 | 0.8 | L_Zuluft | 3.84 |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 350 | 200 | 1500 | 1.65 | L_Zuluft | 7.92 | 970 | 3.84921 | 1.14874 | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 300 | 200 | 1500 | 1.5 | L_Zuluft | 7.2 | 760 | 3.51852 | 1.04656 | 222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 300 | 200 | 1500 | 1.5 | L_Zuluft | 7.2 | 760 | 3.51852 | 1.04656 | 224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 300 | 200 | 1500 | 1.5 | L_Zuluft | 7.2 | 760 | 3.51852 | 1.04656 | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 300 | 200 | 1500 | 1.5 | L_Zuluft | 7.2 | 760 | 3.51852 | 1.04656 | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 350 | 200 | 1500 | 1.65 | L_Zuluft | 7.92 | 970 | 3.84921 | 1.14874 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 350 | 200 | 1500 | 1.65 | L_Zuluft | 7.92 | 970 | 3.84921 | 1.14874 | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 350 | 200 | 1500 | 1.65 | L_Zuluft | 7.92 | 970 | 3.84921 | 1.14874 | 207 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 36 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 550 | 3.81944 | 1.52763 | 223 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 36 | 200 | 200 | 1323.68 | 1.05894 | L_Abluft | 5.08292 | 550 | 3.81944 | 1.34806 | 224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 13 | 400 | 600 | 1500 | 3 | L_Abluft | 19.2 | 3190 | 3.69213 | 0.487282 | 194 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1223.74 | 1.22374 | L_Abluft | 5.87394 | 760 | 3.51852 | 0.853812 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1200 | 1.2 | L_Abluft | 5.76 | 760 | 3.51852 | 0.837251 | 198 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1488.49 | 1.48849 | L_Abluft | 7.14474 | 750 | 3.47222 | 1.01345 | 297 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 500 | 400 | 1000 | 1.8 | L_Zuluft | 8.64 | 2530 | 3.51389 | 0.325651 | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 400 | 1500 | 2.1 | L_Zuluft | 10.08 | 1530 | 3.54167 | 0.681698 | 183 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 400 | 1449.38 | 2.02913 | L_Zuluft | 9.73982 | 1530 | 3.54167 | 0.658692 | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 2 | 400 | 500 | 1000 | 1.8 | L_Abluft | 8.64 | 2590 | 3.59722 | 0.340106 | 34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 490 | 3.40278 | 1.23435 | 171 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 200 | 1469.03 | 1.17522 | L_Abluft | 5.64107 | 490 | 3.40278 | 1.20886 | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 200 | 200 | 1089.2 | 0.871359 | L_Abluft | 4.18252 | 490 | 3.40278 | 0.8963 | 97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 300 | 350 | 1201.88 | 1.56244 | L_Abluft | 7.49971 | 980 | 2.59259 | 0.330939 | 143 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB |  | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 516 | 3.58333 | 1.35779
4 x Luftleitung | EG_Verwaltung_FFB | 181 | 300 | 350 | 1280 | 1.664 | L_Zuluft | 7.9872 | 1442 | 3.81481 | 0.718207 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Luftleitung | EG_Verwaltung_FFB | 181 | 350 | 450 | 1380 | 2.208 | L_Zuluft | 10.5984 | 2163 | 3.81481 | 0.607124 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Luftleitung | EG_Verwaltung_FFB | 181 | 300 | 350 | 1180 | 1.534 | L_Zuluft | 7.3632 | 1442 | 3.81481 | 0.662097 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB |  | 800 | 500 | 1151.03 | 2.99268 | L_Abluft | 19.1531 | 5400 | 3.75 | 0.284269
2 x Luftleitung | EG_Verwaltung_FFB |  | 500 | 300 | 1500 | 2.4 | L_Abluft | 11.52 | 1800 | 3.33333 | 0.545787
2 x Luftleitung | EG_Verwaltung_FFB |  | 500 | 300 | 1000 | 1.6 | L_Abluft | 7.68 | 1800 | 3.33333 | 0.363858
Luftleitung | EG_Verwaltung_FFB |  | 650 | 300 | 1000 | 1.9 | L_Abluft | 12.16 | 2700 | 3.84615 | 0.424392
2 x Luftleitung | EG_Verwaltung_FFB |  | 300 | 650 | 1500 | 2.85 | L_Abluft | 18.24 | 2700 | 3.84615 | 0.636588
Luftleitung | EG_Verwaltung_FFB |  | 300 | 650 | 1000 | 1.9 | L_Abluft | 12.16 | 2700 | 3.84615 | 0.424392
Luftleitung | EG_Verwaltung_FFB |  | 400 | 800 | 1409.81 | 3.38354 | L_Abluft | 21.6547 | 4500 | 3.90625 | 0.447153
Luftleitung | EG_Verwaltung_FFB |  | 300 | 550 | 1399.76 | 2.3796 | L_Abluft | 15.2294 | 2250 | 3.78788 | 0.618405
Luftleitung | EG_Verwaltung_FFB |  | 300 | 550 | 1000 | 1.7 | L_Abluft | 10.88 | 2250 | 3.78788 | 0.441792
2 x Luftleitung | EG_Verwaltung_FFB |  | 450 | 500 | 1135.03 | 2.15657 | L_Zuluft | 10.3515 | 2884 | 3.56049 | 0.350341
2 x Luftleitung | EG_Verwaltung_FFB |  | 800 | 450 | 1301.03 | 3.25257 | L_Zuluft | 20.8165 | 5047 | 3.89429 | 0.373584
Luftleitung | EG_Verwaltung_FFB |  | 350 | 450 | 1055.59 | 1.68894 | L_Zuluft | 8.10692 | 2163 | 3.81481 | 0.464401
Luftleitung | EG_Verwaltung_FFB |  | 800 | 500 | 1326.03 | 3.44768 | L_Zuluft | 22.0651 | 5768 | 4.00556 | 0.370229
Luftleitung | EG_Verwaltung_FFB |  | 500 | 450 | 1170.7 | 2.22434 | L_Zuluft | 10.6768 | 2884 | 3.56049 | 0.361351
Luftleitung | EG_Verwaltung_FFB |  | 450 | 350 | 1351.03 | 2.16165 | L_Zuluft | 10.3759 | 2163 | 3.81481 | 0.594379
Luftleitung | EG_Verwaltung_FFB |  | 400 | 500 | 1326.03 | 2.38685 | L_Zuluft | 11.4569 | 2884 | 4.00556 | 0.550628
Luftleitung | EG_Verwaltung_FFB |  | 500 | 400 | 1000 | 1.8 | L_Zuluft | 8.64 | 2884 | 4.00556 | 0.415245
Luftleitung | EG_Verwaltung_FFB |  | 350 | 300 | 1393.21 | 1.81117 | L_Zuluft | 8.69362 | 1350 | 3.57143 | 0.691889
2 x Luftleitung | EG_Verwaltung_FFB |  | 250 | 300 | 904.502 | 0.994952 | L_Abluft | 4.77577 | 900 | 3.33333 | 0.487479
Luftleitung | EG_Verwaltung_FFB |  | 250 | 300 | 901.502 | 0.991652 | L_Abluft | 4.75993 | 900 | 3.33333 | 0.485862
Luftleitung | EG_Verwaltung_FFB |  | 500 | 350 | 1151.97 | 1.95835 | L_Zuluft | 9.40009
Luftleitung | EG_Verwaltung_FFB |  | 500 | 400 | 1407.46 | 2.53343 | L_Abluft | 12.1605 | 2700 | 3.75 | 0.517076
Luftleitung | EG_Verwaltung_FFB |  | 500 | 250 | 1174.73 | 1.7621 | L_Zuluft | 8.45808
Luftleitung | EG_Verwaltung_FFB |  | 350 | 300 | 1176.97 | 1.53006 | L_Abluft | 7.3443 | 1350 | 3.57143 | 0.584503
Luftleitung | EG_Verwaltung_FFB |  | 400 | 350 | 1375.67 | 2.0635 | L_Zuluft | 9.90479
Luftleitung | EG_Verwaltung_FFB |  | 350 | 250 | 1230.31 | 1.47637 | L_Zuluft | 7.08658
Luftleitung | EG_Verwaltung_FFB |  | 250 | 500 | 1281.62 | 1.92243 | L_Zuluft | 9.22767
Luftleitung | EG_Verwaltung_FFB |  | 250 | 200 | 973.853 | 0.876468 | L_Abluft | 4.20705
Luftleitung | EG_Verwaltung_FFB |  | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64
Luftleitung | EG_Verwaltung_FFB |  | 300 | 400 | 949.814 | 1.32974 | L_Abluft | 6.38275
Luftleitung | EG_Verwaltung_FFB |  | 300 | 400 | 1184.42 | 1.65819 | L_Zuluft | 7.9593
Luftleitung | EG_Verwaltung_FFB |  | 800 | 500 | 1176.03 | 3.05768 | L_Abluft | 19.5691
Luftleitung | EG_Verwaltung_FFB |  | 600 | 400 | 1098.17 | 2.19634 | L_Abluft | 14.0566
Luftleitung | EG_Verwaltung_FFB |  | 650 | 350 | 1000 | 2 | L_Zuluft | 12.8
Luftleitung | EG_Verwaltung_FFB |  | 500 | 200 | 936.663 | 1.31133 | L_Zuluft | 6.29438

# IfcFlowSegment: Luftleitungsteil (469)
Description: Luftleitungsteil
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Luftleitungsteil; Abbreviation: LT
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitungsteil | Wartung_FFB | 93 | 1530 | 918 | 393.91 | 1.92858 | L_Aussenluft | 15.4287 | 10190 | 2.01529 | 0.0145091 | 877 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 93 | 900 | 900 | 652.808 | 2.35011 | L_Aussenluft | 15.0407 | 10190 | 3.49451 | 0.0891708 | 883 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 900 | 900 | 712.726 | 2.56581 | L_Fortluft | 16.4212 | 10190 | 3.49451 | 0.0973553 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 59 | 650 | 500 | 400 | 1 | L_Zuluft | 5.888 | 4380 | 3.74359 | 0.109213 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 700 | 600 | 652.889 | 1.69751 | L_Zuluft | 10.8641 | 5740 | 3.7963 | 0.155462 | 356 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 1530 | 918 | 776.909 | 3.80375 | L_Abluft | 30.43 | 10190 | 2.01529 | 0.0286164 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 28 | 918 | 612 | 806.752 | 2.46866 | L_Aussenluft | 15.7994 | 3300 | 1.63161 | 0.0347506 | 257 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 28 | 918 | 612 | 290.659 | 1 | L_Aussenluft | 5.69226 | 3300 | 1.63161 | 0.01252 | 255 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 458.999 | 1.40454 | L_Abluft | 8.98904 | 3300 | 1.63161 | 0.0197713 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 850.027 | 2.60108 | L_Abluft | 16.6469 | 3300 | 1.63161 | 0.0366147 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 107.059 | 1 | L_Abluft | 2.09665 | 3300 | 1.63161 | 0.00461155 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 500 | 500 | 532.332 | 1.06466 | L_Abluft | 5.11038 | 3300 | 3.66667 | 0.162415 | 42 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 500 | 500 | 847 | 1.694 | L_Abluft | 8.1312 | 3300 | 3.66667 | 0.25842 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 500 | 215.715 | 1 | L_Zuluft | 2.07086 | 3300 | 3.66667 | 0.0658147 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 500 | 637.759 | 1.27552 | L_Zuluft | 6.12249 | 3300 | 3.66667 | 0.194581 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 28 | 500 | 500 | 519.897 | 1.03979 | L_Aussenluft | 4.99101 | 3300 | 3.66667 | 0.158621 | 268 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 28 | 612 | 918 | 136.661 | 1 | L_Aussenluft | 2.67637 | 3300 | 1.63161 | 0.00588663 | 263 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 500 | 519.897 | 1.03979 | L_Fortluft | 4.99101 | 3300 | 3.66667 | 0.158621 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 30 | 500 | 400 | 511.897 | 1 | L_Fortluft | 4.42279 | 2530 | 3.51389 | 0.1667 | 374 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 612 | 612 | 806.752 | 1.97493 | L_Aussenluft | 12.6395 | 2530 | 1.87636 | 0.0560421 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 612 | 612 | 290.659 | 1 | L_Aussenluft | 4.55381 | 2530 | 1.87636 | 0.020191 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 612 | 612 | 806.752 | 1.97493 | L_Abluft | 12.6395 | 2590 | 1.92085 | 0.0584904 | 3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 30 | 612 | 612 | 138.659 | 1 | L_Fortluft | 2.17239 | 2530 | 1.87636 | 0.00963211 | 362 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 400 | 363.142 | 1 | L_Aussenluft | 3.13755 | 2530 | 3.51389 | 0.118258 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 400 | 715.13 | 1.28723 | L_Aussenluft | 6.17872 | 2530 | 3.51389 | 0.232883 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 500 | 400 | 725 | 1.305 | L_Zuluft | 6.264 | 2530 | 3.51389 | 0.236097 | 68 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 400 | 725 | 1.305 | L_Abluft | 6.264 | 2590 | 3.59722 | 0.246577 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 400 | 500 | 749.455 | 1.34902 | L_Abluft | 6.47529 | 2590 | 3.59722 | 0.254894 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 400 | 500 | 471 | 1 | L_Abluft | 4.06944 | 2590 | 3.59722 | 0.16019 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 918 | 612 | 806.752 | 2.46866 | L_Aussenluft | 15.7994 | 3520 | 1.74039 | 0.0390879 | 121 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 918 | 612 | 213.662 | 1 | L_Aussenluft | 4.18435 | 3520 | 1.74039 | 0.0103521 | 119 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 612 | 918 | 382.998 | 1.17197 | L_Abluft | 7.50062 | 3520 | 1.74039 | 0.0185566 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 806.752 | 2.46866 | L_Abluft | 15.7994 | 3520 | 1.74039 | 0.0390879 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 138.661 | 1 | L_Abluft | 2.71554 | 3520 | 1.74039 | 0.00671827 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 450 | 600 | 600.104 | 1.26022 | L_Aussenluft | 8.06539 | 3520 | 3.6214 | 0.172868 | 143 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 600 | 450 | 842.824 | 1.76993 | L_Fortluft | 11.3276 | 3520 | 3.6214 | 0.242786 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 450 | 600 | 714.686 | 1.50084 | L_Abluft | 9.60538 | 3520 | 3.6214 | 0.205875 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 600 | 520.364 | 1.1448 | L_Zuluft | 7.32672 | 4670 | 4.32407 | 0.194047 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 4 | 500 | 600 | 879 | 1.9338 | L_Abluft | 12.3763 | 4110 | 3.80556 | 0.258402 | 185 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 918 | 612 | 806.752 | 2.46866 | L_Aussenluft | 15.7994 | 4120 | 2.03704 | 0.052114 | 567 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 612 | 918 | 372.716 | 1.14051 | L_Abluft | 7.29927 | 4610 | 2.27931 | 0.029587 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 806.752 | 2.46866 | L_Abluft | 15.7994 | 4610 | 2.27931 | 0.0640417 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 918 | 612 | 148.943 | 1 | L_Abluft | 2.91689 | 4610 | 2.27931 | 0.0118234 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 600 | 500 | 564 | 1.2408 | L_Aussenluft | 7.94112 | 4120 | 3.81481 | 0.166551 | 585 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 600 | 500 | 562.674 | 1.23788 | L_Aussenluft | 7.92245 | 4120 | 3.81481 | 0.16616 | 596 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 193 | 2448 | 2448 | 848.162 | 8.30521 | L_Aussenluft | 73.0858 | 45900 | 2.12759 | 0.0138828 | 651 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 2142 | 2448 | 529 | 4.85622 | L_Aussenluft | 42.7347 | 32600 | 1.72697 | 0.00640246 | 73 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 2142 | 2448 | 530 | 4.8654 | L_Fortluft | 42.8155 | 32600 | 1.72697 | 0.00641456 | 3 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 19 | 500 | 1400 | 400 | 1.52 | L_Abluft | 12.16 | 8200 | 3.25397 | 0.0609891 | 93 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 13 | 1400 | 500 | 400 | 1.52 | L_Abluft | 12.16 | 8200 | 3.25397 | 0.0609891 | 121 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 82 | 300 | 350 | 684.917 | 1 | L_Zuluft | 4.27388 | 1300 | 3.43915 | 0.317216 | 445 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 81 | 350 | 350 | 775.995 | 1.08639 | L_Zuluft | 5.21469 | 1600 | 3.62812 | 0.359519 | 428 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 76 | 600 | 800 | 428.976 | 1.20113 | L_Zuluft | 7.68725 | 7100 | 4.1088 | 0.110117 | 357 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 83 | 300 | 250 | 485.684 | 1 | L_Zuluft | 2.56441 | 975 | 3.61111 | 0.303453 | 457 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 600 | 450 | 730.1 | 1.53321 | L_Aussenluft | 9.81254 | 3520 | 3.6214 | 0.210315 | 153 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 600 | 500 | 616.702 | 1.35675 | L_Aussenluft | 8.68317 | 4120 | 3.81481 | 0.182114 | 605 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 600 | 500 | 700 | 1.54 | L_Aussenluft | 9.856 | 4120 | 3.81481 | 0.206712 | 603 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 600 | 450 | 356.112 | 1 | L_Aussenluft | 4.78615 | 3520 | 3.6214 | 0.102583 | 151 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 115 | 350 | 350 | 326.229 | 1 | L_Zuluft | 2.19226 | 1625 | 3.68481 | 0.155545 | 231 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 1800 | 2000 | 648.88 | 4.93149 | L_Abluft | 39.4519 | 33461 | 2.58187 | 0.0206402 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 2000 | 1800 | 499.798 | 3.79846 | L_Zuluft | 30.3877 | 35186 | 2.71497 | 0.0174505 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 2000 | 1800 | 665.139 | 5.05505 | L_Zuluft | 40.4404 | 35186 | 2.71497 | 0.0232233 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 72 | 1500 | 700 | 586.863 | 2.5822 | L_Zuluft | 20.6576 | 16525 | 4.37169 | 0.113366 | 82 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 5 | 1500 | 700 | 656.789 | 2.88987 | L_Zuluft | 23.119 | 14475 | 3.82937 | 0.099075 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 1500 | 1400 | 492.705 | 2.85769 | L_Zuluft | 22.8615 | 30925 | 4.09061 | 0.0509204 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1500 | 1400 | 548.185 | 3.17947 | L_Aussenluft | 25.4358 | 32600 | 4.31217 | 0.0625333 | 91 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1400 | 1500 | 640.5 | 3.7149 | L_Aussenluft | 29.7192 | 32600 | 4.31217 | 0.0730639 | 110 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1500 | 1400 | 553.429 | 3.20989 | L_Aussenluft | 25.6791 | 32600 | 4.31217 | 0.0631315 | 81 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 111 | 700 | 500 | 730.829 | 1.75399 | L_Zuluft | 11.2255 | 6900 | 5.47619 | 0.39084 | 168 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 110 | 700 | 500 | 730.829 | 1.75399 | L_Zuluft | 11.2255 | 7225 | 5.73413 | 0.42616 | 153 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 600 | 500 | 866.558 | 1.90643 | L_Aussenluft | 12.2011 | 4120 | 3.81481 | 0.255898 | 592 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 600 | 500 | 658.887 | 1.44955 | L_Aussenluft | 9.27713 | 4120 | 3.81481 | 0.194572 | 587 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 600 | 500 | 296.352 | 1 | L_Fortluft | 4.17264 | 4120 | 3.81481 | 0.0875137 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 600 | 500 | 249.504 | 1 | L_Fortluft | 3.51301 | 4120 | 3.81481 | 0.0736793 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 1500 | 1400 | 553.429 | 3.20989 | L_Fortluft | 25.6791 | 32600 | 4.31217 | 0.0631315 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 1500 | 1400 | 658.134 | 3.81718 | L_Fortluft | 30.5374 | 32600 | 4.31217 | 0.0750754 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 1400 | 1000 | 350.245 | 1.68117 | L_Fortluft | 13.4494 | 16300 | 3.23413 | 0.03029 | 46 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 3 | 1400 | 1000 | 735.442 | 3.53012 | L_Fortluft | 28.241 | 16300 | 3.23413 | 0.0636028 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 900 | 900 | 692.112 | 2.4916 | L_Fortluft | 15.9463 | 10190 | 3.49451 | 0.0945395 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 47 | 300 | 350 | 684.917 | 1 | L_Zuluft | 4.27388 | 1300 | 3.43915 | 0.317216 | 158 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 46 | 350 | 350 | 775.995 | 1.08639 | L_Zuluft | 5.21469 | 1625 | 3.68481 | 0.369992 | 141 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 41 | 600 | 800 | 744.76 | 2.08533 | L_Zuluft | 13.3461 | 7225 | 4.18113 | 0.197503 | 68 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1982 | 3059 | 300 | 3.0246 | L_Aussenluft | 26.6165 | 32600 | 1.49359 | 0.00261486 | 127 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 20 | 350 | 300 | 790.412 | 1.02754 | L_Zuluft | 4.93217 | 1400 | 3.7037 | 0.419864 | 302 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 20 | 350 | 300 | 233.293 | 1 | L_Zuluft | 1.45575 | 1400 | 3.7037 | 0.123924 | 300 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 15 | 600 | 800 | 474.023 | 1.32726 | L_Zuluft | 8.4945 | 7000 | 4.05093 | 0.118505 | 241 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 400 | 725.3 | 1.30554 | L_Aussenluft | 6.26659 | 2530 | 3.51389 | 0.236195 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 39 | 800 | 700 | 551.262 | 1.65379 | L_Zuluft | 10.5842 | 7875 | 3.90625 | 0.116147 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 39 | 700 | 800 | 314.161 | 1 | L_Zuluft | 6.0319 | 7875 | 3.90625 | 0.0661917 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 3 | 600 | 700 | 358.052 | 1 | L_Abluft | 5.95799 | 5810 | 3.84259 | 0.0872014 | 402 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 3 | 600 | 700 | 653.135 | 1.69815 | L_Abluft | 10.8682 | 5810 | 3.84259 | 0.159067 | 406 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 3 | 700 | 700 | 250 | 1 | L_Abluft | 4.48 | 5810 | 3.29365 | 0.0414903 | 408 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 3 | 700 | 600 | 625.992 | 1.62758 | L_Abluft | 10.4165 | 5810 | 3.84259 | 0.152457 | 410 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 600 | 700 | 625.992 | 1.62758 | L_Zuluft | 10.4165 | 5740 | 3.7963 | 0.149057 | 377 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 600 | 700 | 724.601 | 1.88396 | L_Zuluft | 12.0574 | 5740 | 3.7963 | 0.172537 | 372 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 600 | 700 | 680.523 | 1.76936 | L_Zuluft | 11.3239 | 5740 | 3.7963 | 0.162042 | 375 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 193 | 1400 | 2200 | 867.128 | 6.24332 | L_Aussenluft | 54.9413 | 45900 | 4.13961 | 0.0750564 | 674 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 193 | 2448 | 2000 | 156.4 | 1.39133 | L_Aussenluft | 12.2437 | 45900 | 2.60417 | 0.00422449 | 654 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 193 | 1400 | 2200 | 375.703 | 2.70506 | L_Aussenluft | 23.8045 | 45900 | 4.13961 | 0.0325199 | 681 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 81 | 2200 | 1400 | 627.685 | 4.51933 | L_Fortluft | 39.7701 | 41900 | 3.77886 | 0.0458127 | 540 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 81 | 2448 | 2000 | 246.687 | 2.19453 | L_Fortluft | 19.3118 | 41900 | 2.37722 | 0.00562773 | 529 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 600 | 450 | 510.407 | 1.07186 | L_Fortluft | 6.85988 | 3520 | 3.6214 | 0.14703 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 600 | 450 | 722.39 | 1.51702 | L_Fortluft | 9.70893 | 3520 | 3.6214 | 0.208094 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 450 | 600 | 793.559 | 1.66647 | L_Fortluft | 10.6654 | 3520 | 3.6214 | 0.228595 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 900 | 900 | 680.394 | 2.44942 | L_Zuluft | 15.6763 | 10120 | 3.47051 | 0.0917556 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 900 | 900 | 382.635 | 1.37749 | L_Abluft | 8.81591 | 10190 | 3.49451 | 0.0522663 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 25 | 600 | 1000 | 703.677 | 2.25177 | L_Abluft | 14.4113 | 8200 | 3.7963 | 0.139826 | 73 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 500 | 487.71 | 1 | L_Zuluft | 4.68202 | 3300 | 3.66667 | 0.148801 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 500 | 500 | 659.71 | 1.31942 | L_Zuluft | 6.33322 | 3300 | 3.66667 | 0.201278 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 171 | 700 | 500 | 351.556 | 1 | L_Zuluft | 5.3999 | 4720 | 3.74603 | 0.0924828 | 308 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 4 | 700 | 500 | 354.556 | 1 | L_Abluft | 5.44598 | 4961 | 3.9373 | 0.102323 | 455 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 33 | 1300 | 1400 | 573.986 | 3.09952 | L_Zuluft | 24.7962 | 20909 | 3.19124 | 0.0406917 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 33 | 1400 | 1300 | 618.785 | 3.34144 | L_Zuluft | 26.7315 | 20909 | 3.19124 | 0.0438677 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 37 | 1000 | 800 | 860.692 | 3.09849 | L_Zuluft | 19.8303 | 10094 | 3.50486 | 0.120004 | 340 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 61 | 700 | 400 | 226.199 | 1 | L_Abluft | 3.18488 | 3600 | 3.57143 | 0.064294 | 141 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 61 | 700 | 400 | 352.671 | 1 | L_Abluft | 4.9656 | 3600 | 3.57143 | 0.100242 | 143 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 69 | 800 | 500 | 302.671 | 1 | L_Abluft | 5.03644 | 5400 | 3.75 | 0.0747504 | 92 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 69 | 500 | 800 | 388.989 | 1.01137 | L_Abluft | 6.47277 | 5400 | 3.75 | 0.0960682 | 85 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 77 | 300 | 500 | 358.151 | 1 | L_Abluft | 2.7506 | 2000 | 3.7037 | 0.158371 | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 61 | 700 | 400 | 305.481 | 1 | L_Abluft | 4.30117 | 3600 | 3.57143 | 0.0868288 | 137 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 69 | 800 | 500 | 254.196 | 1 | L_Abluft | 4.22982 | 5400 | 3.75 | 0.0627787 | 83 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 53 | 800 | 500 | 358.152 | 1 | L_Abluft | 5.95965 | 5400 | 3.75 | 0.0884525 | 189 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 1600 | 1800 | 565.612 | 3.84616 | L_Abluft | 30.7693 | 33461 | 3.22733 | 0.0311312 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 18 | 350 | 500 | 642.821 | 1.0928 | L_Zuluft | 5.24542 | 2202 | 3.49524 | 0.227637 | 529 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 18 | 500 | 350 | 684.98 | 1.16447 | L_Zuluft | 5.58944 | 2202 | 3.49524 | 0.242566 | 535 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 35 | 800 | 400 | 553.84 | 1.32922 | L_Abluft | 8.50698 | 4500 | 3.90625 | 0.175663 | 317 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 35 | 400 | 800 | 252.311 | 1 | L_Abluft | 3.8755 | 4500 | 3.90625 | 0.0800262 | 311 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 18 | 500 | 350 | 687.294 | 1.1684 | L_Zuluft | 5.60832 | 2202 | 3.49524 | 0.243385 | 531 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 7 | 350 | 300 | 306.441 | 1 | L_Zuluft | 1.91219 | 1350 | 3.57143 | 0.152184 | 589 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 7 | 300 | 350 | 205.022 | 1 | L_Zuluft | 1.27934 | 1350 | 3.57143 | 0.101817 | 583 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 18 | 350 | 500 | 203.277 | 1 | L_Zuluft | 1.65874 | 2202 | 3.49524 | 0.0719846 | 524 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 43 | 550 | 300 | 182.752 | 1 | L_Abluft | 1.98834 | 2200 | 3.7037 | 0.077441 | 277 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 47 | 350 | 300 | 673.375 | 1 | L_Abluft | 4.20186 | 1350 | 3.57143 | 0.334409 | 244 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 47 | 350 | 300 | 183.609 | 1 | L_Abluft | 1.14572 | 1350 | 3.57143 | 0.091183 | 242 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 1000 | 1400 | 772.112 | 3.70614 | L_Abluft | 29.6491 | 17061 | 3.38512 | 0.0726846 | 232 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 1600 | 1800 | 550 | 3.74 | L_Abluft | 29.92 | 31461 | 3.03443 | 0.0269938 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 1200 | 1000 | 355.608 | 1.56467 | L_Zuluft | 12.5174 | 14277 | 3.30486 | 0.0347133 | 513 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 900 | 900 | 598.505 | 2.15462 | L_Fortluft | 13.7896 | 10190 | 3.49451 | 0.0817532 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 400 | 500 | 699.743 | 1.25954 | L_Aussenluft | 6.04578 | 2530 | 3.51389 | 0.227872 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 1 | 400 | 500 | 795.092 | 1.43116 | L_Aussenluft | 6.86959 | 2530 | 3.51389 | 0.258922 | 44 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 28 | 500 | 500 | 795.092 | 1.59018 | L_Aussenluft | 7.63288 | 3300 | 3.66667 | 0.242583 | 290 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 43 | 550 | 300 | 857.088 | 1.45705 | L_Abluft | 9.32512 | 2200 | 3.7037 | 0.363191 | 280 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 43 | 550 | 300 | 293.934 | 1 | L_Abluft | 3.198 | 2200 | 3.7037 | 0.124555 | 282 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 4 | 700 | 500 | 744.749 | 1.7874 | L_Abluft | 11.4394 | 4961 | 3.9373 | 0.21493 | 465 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 171 | 500 | 700 | 705.175 | 1.69242 | L_Zuluft | 10.8315 | 4720 | 3.74603 | 0.185508 | 318 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 4 | 500 | 750 | 572.91 | 1.43228 | L_Zuluft | 9.16656 | 5362.5 | 3.97222 | 0.162413 | 641 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 6 | 600 | 500 | 150 | 1 | L_Zuluft | 2.112 | 3552 | 3.28889 | 0.0336406 | 520 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 1200 | 1000 | 889.167 | 3.91233 | L_Zuluft | 31.2987 | 14277 | 3.30486 | 0.0867976 | 504 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 6 | 700 | 750 | 234.121 | 1 | L_Zuluft | 4.34528 | 7237.5 | 3.82937 | 0.0493341 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 6 | 700 | 750 | 234.121 | 1 | L_Zuluft | 4.34528 | 7237.5 | 3.82937 | 0.0493341 | 44 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 10 | 800 | 1500 | 697.43 | 3.20818 | L_Zuluft | 25.6654 | 16450 | 3.80787 | 0.093501 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 11 | 800 | 700 | 614.901 | 1.8447 | L_Zuluft | 11.8061 | 8250 | 4.09226 | 0.141291 | 199 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 11 | 700 | 800 | 725.977 | 2.17793 | L_Zuluft | 13.9388 | 8250 | 4.09226 | 0.166814 | 205 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 11 | 800 | 700 | 667.981 | 2.00394 | L_Zuluft | 12.8252 | 8250 | 4.09226 | 0.153488 | 203 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 25 | 1200 | 500 | 470.325 | 1.5991 | L_Abluft | 12.7928 | 8200 | 3.7963 | 0.100588 | 66 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 6 | 1000 | 1200 | 717.143 | 3.15543 | L_Abluft | 25.2434 | 16400 | 3.7963 | 0.090614 | 110 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 6 | 1200 | 1000 | 600.045 | 2.6402 | L_Abluft | 21.1216 | 16400 | 3.7963 | 0.0758181 | 101 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1500 | 1400 | 298.112 | 1.72905 | L_Aussenluft | 13.8324 | 32600 | 4.31217 | 0.0340066 | 98 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1500 | 1400 | 298.112 | 1.72905 | L_Aussenluft | 13.8324 | 32600 | 4.31217 | 0.0340066 | 102 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 8 | 1400 | 1500 | 651.756 | 3.78018 | L_Aussenluft | 30.2415 | 32600 | 4.31217 | 0.0743479 | 104 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 93 | 900 | 900 | 412.259 | 1.48413 | L_Aussenluft | 9.49845 | 10190 | 3.49451 | 0.0563128 | 890 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 93 | 900 | 900 | 553.548 | 1.99277 | L_Aussenluft | 12.7538 | 10190 | 3.49451 | 0.0756123 | 893 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 93 | 900 | 900 | 412.259 | 1.48413 | L_Aussenluft | 9.49845 | 10190 | 3.49451 | 0.0563128 | 895 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 93 | 900 | 900 | 466.373 | 1.67894 | L_Aussenluft | 10.7452 | 10190 | 3.49451 | 0.0637045 | 897 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 2 | 500 | 500 | 628.11 | 1.25622 | L_Abluft | 6.02986 | 3300 | 3.66667 | 0.191637 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 41 | 600 | 800 | 482.494 | 1.35098 | L_Zuluft | 8.64628 | 7225 | 4.18113 | 0.127953 | 73 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 41 | 600 | 800 | 517.506 | 1.44902 | L_Zuluft | 9.27372 | 7225 | 4.18113 | 0.137238 | 75 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 28 | 500 | 500 | 657.835 | 1.31567 | L_Aussenluft | 6.31521 | 3300 | 3.66667 | 0.200706 | 292 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 600 | 450 | 625.833 | 1.31425 | L_Aussenluft | 8.4112 | 3520 | 3.6214 | 0.180279 | 139 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 600 | 450 | 446.41 | 1 | L_Aussenluft | 5.99975 | 3520 | 3.6214 | 0.128594 | 141 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 17 | 450 | 600 | 543.321 | 1.14097 | L_Aussenluft | 7.30223 | 3520 | 3.6214 | 0.156511 | 136 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 3 | 1500 | 500 | 666.509 | 2.66604 | L_Zuluft | 21.3283 | 10725 | 3.97222 | 0.1441 | 630 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB | 4 | 500 | 750 | 572.91 | 1.43228 | L_Zuluft | 9.16656 | 5362.5 | 3.97222 | 0.162413 | 637 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | Wartung_FFB |  | 1000 | 600 | 240.025 | 1 | L_Zuluft | 4.91572
Luftleitungsteil | Wartung_FFB |  | 1000 | 600 | 665.683 | 2.13019 | L_Zuluft | 13.6332
Luftleitungsteil | Wartung_FFB |  | 1200 | 2000 | 581.61 | 3.7223 | L_Abluft | 29.7784 | 32800 | 3.7963 | 0.0501267
Luftleitungsteil | Wartung_FFB |  | 500 | 700 | 300.073 | 1 | L_Zuluft | 4.60913
Luftleitungsteil | Wartung_FFB |  | 4060 | 2274 | 200 | 2.5336 | L_Fortluft | 22.2957 | 41900 | 1.26065 | 0.00101484
Luftleitungsteil | Wartung_FFB |  | 4848 | 2174 | 200 | 2.8088 | L_Aussenluft | 24.7174 | 45900 | 1.20973 | 0.000908632
Luftleitungsteil | Wartung_FFB |  | 1000 | 600 | 760.604 | 2.43393 | L_Zuluft | 15.5772
Luftleitungsteil | Wartung_FFB |  | 1000 | 600 | 361.665 | 1.15733 | L_Zuluft | 7.40691
Luftleitungsteil | Wartung_FFB |  | 1500 | 800 | 339.979 | 1.56391 | L_Zuluft | 12.5112
Luftleitungsteil | Wartung_FFB |  | 1500 | 800 | 734.273 | 3.37766 | L_Zuluft | 27.0213 | 16450 | 3.80787 | 0.0984404
Luftleitungsteil | Wartung_FFB |  | 1500 | 800 | 676.232 | 3.11067 | L_Zuluft | 24.8853 | 16450 | 3.80787 | 0.0906591
Luftleitungsteil | Wartung_FFB |  | 1500 | 800 | 832.455 | 3.82929 | L_Zuluft | 30.6343
Luftleitungsteil | Wartung_FFB |  | 1500 | 700 | 666.804 | 2.93394 | L_Zuluft | 23.4715 | 14475 | 3.82937 | 0.100586
Luftleitungsteil | Wartung_FFB |  | 1500 | 700 | 702.854 | 3.09256 | L_Zuluft | 24.7404 | 14475 | 3.82937 | 0.106024
Luftleitungsteil | Wartung_FFB |  | 1000 | 500 | 600 | 1.8 | L_Zuluft | 11.52 | 7237.5 | 4.02083 | 0.153075
Luftleitungsteil | Wartung_FFB |  | 1000 | 500 | 312.232 | 1 | L_Zuluft | 5.99485 | 7237.5 | 4.02083 | 0.0796583
Luftleitungsteil | Wartung_FFB |  | 1500 | 700 | 316.078 | 1.39074 | L_Zuluft | 11.126
Luftleitungsteil | Wartung_FFB |  | 750 | 500 | 317.157 | 1 | L_Zuluft | 5.07452 | 5362.5 | 3.97222 | 0.0899102
Luftleitungsteil | Wartung_FFB |  | 750 | 500 | 712.436 | 1.78109 | L_Zuluft | 11.399 | 5362.5 | 3.97222 | 0.201967
Luftleitungsteil | Wartung_FFB |  | 750 | 500 | 695.772 | 1.73943 | L_Zuluft | 11.1324 | 5362.5 | 3.97222 | 0.197243
Luftleitungsteil | Wartung_FFB |  | 750 | 500 | 312.436 | 1 | L_Zuluft | 4.99897 | 5362.5 | 3.97222 | 0.0885716
Luftleitungsteil | Wartung_FFB |  | 500 | 500 | 773.769 | 1.54754 | L_Abluft | 7.42818 | 3300 | 3.66667 | 0.236077
Luftleitungsteil | Wartung_FFB |  | 500 | 500 | 374.831 | 1 | L_Abluft | 3.59837 | 3300 | 3.66667 | 0.114361
Luftleitungsteil | Wartung_FFB |  | 500 | 500 | 662.71 | 1.32542 | L_Abluft | 6.36202 | 3300 | 3.66667 | 0.202193
Luftleitungsteil | Wartung_FFB |  | 500 | 300 | 366.689 | 1 | L_Abluft | 2.81617 | 2000 | 3.7037 | 0.162146
Luftleitungsteil | Wartung_FFB |  | 500 | 300 | 556.142 | 1 | L_Abluft | 4.27117 | 2000 | 3.7037 | 0.245921
Luftleitungsteil | Wartung_FFB |  | 500 | 300 | 175.825 | 1 | L_Abluft | 1.35034 | 2000 | 3.7037 | 0.0777482
Luftleitungsteil | Wartung_FFB |  | 500 | 300 | 450.001 | 1 | L_Abluft | 3.45601 | 2000 | 3.7037 | 0.198986
Luftleitungsteil | Wartung_FFB |  | 300 | 500 | 83.2523 | 1 | L_Abluft | 0.639377 | 2000 | 3.7037 | 0.0368134
Luftleitungsteil | Wartung_FFB |  | 450 | 800 | 858.152 | 2.14538 | L_Zuluft | 13.7304 | 5047 | 3.89429 | 0.246414
Luftleitungsteil | Wartung_FFB |  | 800 | 450 | 760.902 | 1.90225 | L_Zuluft | 12.1744 | 5047 | 3.89429 | 0.218489
Luftleitungsteil | Wartung_FFB |  | 1000 | 400 | 675.244 | 1.89068 | L_Zuluft | 12.1004 | 5047 | 3.50486 | 0.160977
Luftleitungsteil | Wartung_FFB |  | 400 | 500 | 604.626 | 1.08833 | L_Abluft | 5.22397 | 2700 | 3.75 | 0.222129
Luftleitungsteil | Wartung_FFB |  | 400 | 500 | 698.179 | 1.25672 | L_Abluft | 6.03226 | 2700 | 3.75 | 0.256498
Luftleitungsteil | Wartung_FFB |  | 300 | 350 | 604.626 | 1 | L_Abluft | 3.77287 | 1350 | 3.57143 | 0.300267
Luftleitungsteil | Wartung_FFB |  | 350 | 300 | 198.179 | 1 | L_Abluft | 1.23664 | 1350 | 3.57143 | 0.0984188
Luftleitungsteil | Wartung_FFB |  | 400 | 350 | 607.626 | 1 | L_Zuluft | 4.37491
Luftleitungsteil | Wartung_FFB |  | 500 | 350 | 607.626 | 1.03296 | L_Zuluft | 4.95823
Luftleitungsteil | Wartung_FFB |  | 400 | 350 | 195.179 | 1 | L_Zuluft | 1.40529
Luftleitungsteil | Wartung_FFB |  | 600 | 500 | 251.341 | 1 | L_Zuluft | 3.53889
Luftleitungsteil | Wartung_FFB |  | 600 | 500 | 521.226 | 1.1467 | L_Abluft | 7.33886 | 4050 | 3.75 | 0.149096
Luftleitungsteil | Wartung_FFB |  | 500 | 350 | 745.179 | 1.2668 | L_Zuluft | 6.08066
Luftleitungsteil | Wartung_FFB |  | 600 | 500 | 598.496 | 1.31669 | L_Zuluft | 8.42682
Luftleitungsteil | Wartung_FFB |  | 1200 | 500 | 648.548 | 2.20506 | L_Abluft | 17.6405 | 9011 | 4.17176 | 0.165352
Luftleitungsteil | Wartung_FFB |  | 500 | 600 | 300 | 1 | L_Abluft | 4.224 | 4050 | 3.75 | 0.0858144
Luftleitungsteil | Wartung_FFB |  | 500 | 600 | 888.466 | 1.95463 | L_Abluft | 12.5096 | 4050 | 3.75 | 0.254144
Luftleitungsteil | Wartung_FFB |  | 500 | 800 | 425.042 | 1.10511 | L_Abluft | 7.07269 | 5400 | 3.75 | 0.104972
Luftleitungsteil | Wartung_FFB |  | 400 | 700 | 422.042 | 1 | L_Abluft | 5.94235 | 3600 | 3.57143 | 0.119959
Luftleitungsteil | Wartung_FFB |  | 500 | 800 | 422.042 | 1.09731 | L_Abluft | 7.02277 | 5400 | 3.75 | 0.104231
Luftleitungsteil | Wartung_FFB |  | 1000 | 800 | 732.392 | 2.63661 | L_Zuluft | 16.8743 | 10094 | 3.50486 | 0.102115
Luftleitungsteil | Wartung_FFB |  | 1000 | 1200 | 339.839 | 1.49529 | L_Zuluft | 11.9623 | 12978 | 3.00417 | 0.0277916
Luftleitungsteil | Wartung_FFB |  | 1200 | 1000 | 472.87 | 2.08063 | L_Zuluft | 16.645 | 15141 | 3.50486 | 0.051489
Luftleitungsteil | Wartung_FFB |  | 300 | 250 | 806.682 | 1 | L_Zuluft | 4.25928
Luftleitungsteil | Wartung_FFB |  | 300 | 250 | 407.744 | 1 | L_Zuluft | 2.15289
Luftleitungsteil | Wartung_FFB |  | 600 | 700 | 55.7586 | 1 | L_Zuluft | 0.927823
Luftleitungsteil | Wartung_FFB |  | 500 | 400 | 786.934 | 1.41648 | L_Zuluft | 6.79911
Luftleitungsteil | Wartung_FFB |  | 400 | 500 | 429.875 | 1 | L_Zuluft | 3.71412
Luftleitungsteil | EG_Verwaltung_FFB | 29 | 250 | 200 | 854.798 | 1 | L_Abluft | 3.69273 | 475 | 2.63889 | 0.386863 | 750 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 27 | 300 | 250 | 557.898 | 1 | L_Abluft | 2.9457 | 860 | 3.18519 | 0.276511 | 723 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 23 | 300 | 300 | 762.257 | 1 | L_Zuluft | 4.3906 | 1210 | 3.73457 | 0.450531 | 632 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 24 | 400 | 300 | 418.667 | 1 | L_Abluft | 2.81344 | 1540 | 3.56481 | 0.192577 | 654 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 23 | 400 | 350 | 600 | 1 | L_Abluft | 4.32 | 1900 | 3.76984 | 0.459431 | 618 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 78 | 250 | 300 | 673.709 | 1 | L_Zuluft | 3.55718 | 870 | 3.22222 | 0.341098 | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 68 | 400 | 250 | 574.386 | 1 | L_Abluft | 3.58417 | 1310 | 3.63889 | 0.313613 | 341 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 76 | 300 | 450 | 573.05 | 1 | L_Zuluft | 4.12596 | 1700 | 3.49794 | 0.23968 | 180 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 67 | 300 | 450 | 582.063 | 1 | L_Abluft | 4.19085 | 1700 | 3.49794 | 0.24345 | 306 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 75 | 400 | 450 | 617.093 | 1.04906 | L_Zuluft | 5.03548 | 2270 | 3.50309 | 0.211974 | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 66 | 400 | 450 | 617.093 | 1.04906 | L_Abluft | 5.03548 | 2270 | 3.50309 | 0.211974 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 73 | 550 | 400 | 265.783 | 1 | L_Zuluft | 3.23192 | 2940 | 3.71212 | 0.0911047 | 88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 64 | 550 | 400 | 557.423 | 1.0591 | L_Abluft | 6.77826 | 2940 | 3.71212 | 0.191073 | 213 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 60 | 500 | 650 | 482.937 | 1.11076 | L_Zuluft | 7.10884 | 4380 | 3.74359 | 0.131858 | 37 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 61 | 500 | 650 | 374.252 | 1 | L_Abluft | 5.50899 | 4380 | 3.74359 | 0.102183 | 61 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 200 | 250 | 562.821 | 1 | L_Zuluft | 2.43139 | 560 | 3.11111 | 0.344452 | 808 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 200 | 250 | 740.552 | 1 | L_Abluft | 3.19918 | 630 | 3.5 | 0.562998 | 846 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 17 | 450 | 700 | 672.545 | 1.54685 | L_Abluft | 9.89987 | 3875 | 3.41711 | 0.161048 | 416 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 450 | 350 | 700 | 1.12 | L_Zuluft | 5.376 | 1865 | 3.28924 | 0.434655 | 769 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 700 | 450 | 458.415 | 1.05435 | L_Zuluft | 6.74787 | 4435 | 3.91093 | 0.141034 | 418 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 26 | 250 | 200 | 800 | 1 | L_Zuluft | 3.456 | 660 | 3.66667 | 0.662737 | 690 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 25 | 300 | 300 | 314.284 | 1 | L_Abluft | 1.81028 | 1210 | 3.73457 | 0.185757 | 686 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 24 | 300 | 250 | 880 | 1 | L_Zuluft | 4.6464 | 990 | 3.66667 | 0.565565 | 652 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 22 | 300 | 400 | 782.38 | 1.09533 | L_Zuluft | 5.25759 | 1540 | 3.56481 | 0.359876 | 604 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 21 | 400 | 400 | 484.293 | 1 | L_Zuluft | 3.71937 | 1655 | 2.87326 | 0.123773 | 593 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 20 | 250 | 200 | 617.975 | 1 | L_Abluft | 2.66965 | 580 | 3.22222 | 0.403418 | 519 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 20 | 200 | 250 | 356.675 | 1 | L_Abluft | 1.54084 | 580 | 3.22222 | 0.23284 | 506 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 19 | 200 | 300 | 855.303 | 1 | L_Abluft | 4.10546 | 770 | 3.56481 | 0.611331 | 487 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 18 | 300 | 250 | 644.901 | 1 | L_Abluft | 3.40508 | 960 | 3.55556 | 0.391548 | 471 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 500 | 200 | 549.564 | 1 | L_Zuluft | 3.69307 | 1740 | 4.83333 | 0.557164 | 412 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 15 | 500 | 250 | 500 | 1 | L_Abluft | 3.6 | 1900 | 4.22222 | 0.325924 | 391 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 6 | 600 | 300 | 567.616 | 1.02171 | L_Abluft | 6.53894 | 2200 | 3.39506 | 0.197359 | 83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 600 | 400 | 419.804 | 1 | L_Abluft | 5.37349 | 2640 | 3.05556 | 0.0960793 | 71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 600 | 450 | 449.018 | 1 | L_Zuluft | 6.0348 | 3080 | 3.16872 | 0.101008 | 24 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 600 | 350 | 629.372 | 1.19581 | L_Zuluft | 7.65317 | 2640 | 3.49206 | 0.203918 | 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 600 | 300 | 809.033 | 1.45626 | L_Zuluft | 9.32006 | 2200 | 3.39506 | 0.281299 | 52 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 8 | 300 | 350 | 549.291 | 1 | L_Zuluft | 3.42758 | 880 | 2.32804 | 0.124214 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 8 | 300 | 250 | 706.497 | 1 | L_Abluft | 3.7303 | 880 | 3.25926 | 0.365311 | 132 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 300 | 350 | 617.733 | 1 | L_Abluft | 3.85465 | 1270 | 3.35979 | 0.274024 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 200 | 250 | 739.267 | 1 | L_Zuluft | 3.19363 | 630 | 3.5 | 0.562021 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 6 | 200 | 250 | 739.267 | 1 | L_Abluft | 3.19363 | 630 | 3.5 | 0.562021 | 338 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 11 | 200 | 200 | 418.557 | 1 | L_Abluft | 1.60726 | 520 | 3.61111 | 0.384312 | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 21 | 400 | 200 | 715.311 | 1 | L_Abluft | 4.12019 | 1000 | 3.47222 | 0.427404 | 49 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 24 | 200 | 200 | 813.459 | 1 | L_Abluft | 3.12368 | 505 | 3.50694 | 0.707645 | 69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 21 | 200 | 300 | 600 | 1 | L_Zuluft | 2.88 | 780 | 3.61111 | 0.439196 | 110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 22 | 200 | 200 | 697.058 | 1 | L_Zuluft | 2.6767 | 505 | 3.50694 | 0.606385 | 130 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 22 | 200 | 200 | 412.319 | 1 | L_Zuluft | 1.5833 | 505 | 3.50694 | 0.358685 | 124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 21 | 200 | 300 | 128.807 | 1 | L_Zuluft | 0.618273 | 780 | 3.61111 | 0.0942859 | 107 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 20 | 400 | 200 | 576.504 | 1 | L_Zuluft | 3.32066 | 1000 | 3.47222 | 0.344466 | 88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
