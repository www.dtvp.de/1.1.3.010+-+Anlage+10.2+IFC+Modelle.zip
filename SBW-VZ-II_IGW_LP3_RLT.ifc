Properties of the parts of a building model (IFC2X3), part 5 of 18

# IfcFlowFitting: Konisches Übergangsstück (214)
Name | In | Section No | Geom-Main diameter (mm) (mm) | Geom-Secondary diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Konisches Übergangsstück | EG_Verwaltung_FFB | 13 | 140 | 200 | 112 | L_Zuluft | 0.642766 | 822 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 13 | 140 | 200 | 112 | L_Abluft | 2.94535 | 857 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 180 | 125 | 106 | L_Abluft | 0.390702 | 900 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 180 | 125 | 106 | L_Zuluft | 1.7829 | 856 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 11 | 140 | 200 | 112 | L_Abluft | 2.16393 | 896 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 90 | 125 | 160 | 78 | L_Zuluft | 0.458846 | 84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 88 | 125 | 160 | 78 | L_Abluft | 1.04976 | 150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 90 | 125 | 100 | 64 | L_Abluft | 0.192663 | 120 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 87 | 180 | 100 | 140 | L_Abluft | 0.0966161 | 154 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 67 | 125 | 100 | 64 | L_Zuluft | 0.541965 | 314 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 65 | 180 | 125 | 106 | L_Zuluft | 2.06774 | 333 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 66 | 180 | 125 | 106 | L_Zuluft | 2.70072 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 63 | 180 | 100 | 140 | L_Zuluft | 0.724372 | 344 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 80 | 125 | 160 | 78 | L_Abluft | 0.771252 | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 87 | 140 | 160 | 57 | L_Zuluft | 0.146383 | 131 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 78 | 140 | 160 | 57 | L_Abluft | 0.411998 | 257 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 73 | 125 | 160 | 78 | L_Abluft | 1.04976 | 337 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 83 | 125 | 160 | 78 | L_Zuluft | 0.351304 | 196 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 76 | 180 | 200 | 57 | L_Abluft | 0.344389 | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 85 | 180 | 200 | 57 | L_Zuluft | 0.11745 | 166 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 82 | 160 | 200 | 85 | L_Zuluft | 0.374974 | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 74 | 160 | 200 | 85 | L_Abluft | 1.10426 | 323 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 86 | 140 | 160 | 57 | L_Zuluft | 0.202607 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 77 | 140 | 160 | 57 | L_Abluft | 0.570239 | 271 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 88 | 140 | 160 | 57 | L_Zuluft | 0.164112 | 114 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 79 | 140 | 160 | 57 | L_Abluft | 0.461893 | 240 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 89 | 125 | 160 | 78 | L_Zuluft | 0.258101 | 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 81 | 125 | 160 | 78 | L_Abluft | 1.37112 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 9 | 180 | 200 | 57 | L_Zuluft | 0.220409 | 841 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 9 | 200 | 180 | 57 | L_Abluft | 0.125411 | 880 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 33 | 125 | 160 | 78 | L_Zuluft | 0.0448092 | 716 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 35 | 125 | 160 | 78 | L_Abluft | 0.133898 | 758 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 40 | 125 | 160 | 78 | L_Zuluft | 0.237041 | 600 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 54 | 100 | 160 | 112 | L_Abluft | 2.34136 | 499 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 48 | 125 | 100 | 64 | L_Abluft | 0.141548 | 598 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 49 | 100 | 160 | 112 | L_Abluft | 2.34136 | 594 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 47 | 140 | 125 | 51 | L_Abluft | 0.131346 | 586 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 46 | 160 | 140 | 57 | L_Abluft | 0.212864 | 564 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 45 | 180 | 160 | 57 | L_Abluft | 0.173031 | 544 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 44 | 180 | 160 | 57 | L_Zuluft | 0.408733 | 486 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 14 | 140 | 200 | 112 | L_Zuluft | 0.554222 | 534 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 13 | 140 | 200 | 112 | L_Zuluft | 0.526164 | 550 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 200 | 140 | 112 | L_Zuluft | 2.53961 | 554 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 140 | 200 | 112 | L_Zuluft | 0.554222 | 561 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 24 | 140 | 200 | 112 | L_Abluft | 2.53961 | 535 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 23 | 140 | 200 | 112 | L_Abluft | 2.41104 | 551 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 22 | 200 | 140 | 112 | L_Abluft | 0.554222 | 555 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 22 | 140 | 200 | 112 | L_Abluft | 2.53961 | 566 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 25 | 140 | 200 | 112 | L_Abluft | 2.41104 | 502 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 140 | 200 | 112 | L_Abluft | 2.41104 | 483 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 15 | 140 | 200 | 112 | L_Zuluft | 0.526164 | 504 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 20 | 140 | 200 | 112 | L_Zuluft | 0.526164 | 449 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 29 | 140 | 200 | 112 | L_Abluft | 2.41104 | 444 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 19 | 140 | 200 | 112 | L_Zuluft | 0.526164 | 464 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 18 | 140 | 200 | 112 | L_Zuluft | 0.526164 | 487 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 28 | 140 | 200 | 112 | L_Abluft | 2.41104 | 468 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 18 | 200 | 140 | 112 | L_Zuluft | 2.41104 | 468 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 28 | 200 | 140 | 112 | L_Abluft | 0.526164 | 448 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 34 | 140 | 200 | 112 | L_Abluft | 2.94535 | 366 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB |  | 160 | 125 | 78 | L_Zuluft | 0.30291 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Konisches Übergangsstück | EG_Verwaltung_FFB |  | 125 | 200 | 133 | L_Zuluft | 0.705186 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB |  | 180 | 125 | 106 | L_Zuluft | 3.04886 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 125 | 200 | 133 | L_Abluft | 3.84466 | 618 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 180 | 125 | 106 | L_Abluft | 0.668123 | 607 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 11 | 125 | 200 | 133 | L_Abluft | 3.84466 | 603 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 125 | 160 | 78 | L_Abluft | 0.90515 | 589 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 27 | 160 | 125 | 78 | L_Zuluft | 0.258101 | 375 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 28 | 140 | 200 | 112 | L_Zuluft | 0.642766 | 352 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 37 | 125 | 160 | 78 | L_Abluft | 0.771252 | 358 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 39 | 140 | 200 | 112 | L_Zuluft | 0.642766 | 247 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 49 | 140 | 200 | 112 | L_Abluft | 2.94535 | 217 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 40 | 140 | 200 | 112 | L_Zuluft | 0.642766 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 13 | 160 | 180 | 57 | L_Abluft | 0.556331 | 237 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 16 | 125 | 160 | 78 | L_Abluft | 0.30291 | 233 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 14 | 160 | 180 | 57 | L_Zuluft | 0.119255 | 279 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 15 | 125 | 160 | 78 | L_Zuluft | 0.90515 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 16 | 125 | 160 | 78 | L_Zuluft | 0.648066 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 17 | 125 | 160 | 78 | L_Abluft | 0.216877 | 219 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 18 | 180 | 125 | 106 | L_Zuluft | 0.591832 | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 19 | 180 | 125 | 106 | L_Abluft | 2.70072 | 171 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 20 | 125 | 160 | 78 | L_Abluft | 0.458846 | 167 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 19 | 125 | 160 | 78 | L_Zuluft | 1.37112 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 18 | 125 | 160 | 78 | L_Zuluft | 1.37112 | 225 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 19 | 125 | 160 | 78 | L_Abluft | 0.458846 | 188 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 14 | 160 | 125 | 78 | L_Abluft | 2.59227 | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 14 | 125 | 160 | 78 | L_Abluft | 0.867506 | 264 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 9 | 180 | 200 | 57 | L_Zuluft | 0.379688 | 368 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 8 | 180 | 200 | 57 | L_Zuluft | 0.379688 | 376 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 7 | 180 | 200 | 57 | L_Abluft | 0.129489 | 358 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 8 | 180 | 200 | 57 | L_Abluft | 0.129489 | 346 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 29 | 160 | 200 | 85 | L_Abluft | 0.453719 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 28 | 160 | 200 | 85 | L_Abluft | 0.453719 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 160 | 125 | 78 | L_Abluft | 1.04976 | 102 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 125 | 160 | 78 | L_Abluft | 0.351304 | 116 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 24 | 160 | 125 | 78 | L_Zuluft | 0.351304 | 164 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 24 | 125 | 160 | 78 | L_Zuluft | 1.04976 | 178 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 160 | 200 | 85 | L_Zuluft | 1.33616 | 140 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 27 | 160 | 200 | 85 | L_Zuluft | 1.33616 | 120 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 22 | 160 | 200 | 85 | L_Abluft | 0.29038 | 141 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 28 | 160 | 200 | 85 | L_Zuluft | 0.85514 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 6 | 160 | 200 | 85 | L_Zuluft | 0.374974 | 230 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 5 | 160 | 200 | 85 | L_Zuluft | 0.374974 | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 7 | 160 | 200 | 85 | L_Abluft | 1.10426 | 286 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 160 | 200 | 85 | L_Zuluft | 0.345576 | 214 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 11 | 160 | 200 | 85 | L_Abluft | 1.01769 | 270 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 6 | 160 | 200 | 85 | L_Abluft | 1.10426 | 302 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 160 | 200 | 85 | L_Abluft | 1.10426 | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 11 | 160 | 200 | 85 | L_Zuluft | 0.374974 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 160 | 200 | 85 | L_Zuluft | 0.374974 | 192 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 14 | 160 | 200 | 85 | L_Abluft | 1.10426 | 221 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 13 | 100 | 160 | 112 | L_Zuluft | 0.595725 | 172 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 47 | 140 | 200 | 112 | L_Abluft | 2.94535 | 257 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 31 | 200 | 160 | 85 | L_Zuluft | 0.572449 | 268 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 33 | 160 | 100 | 112 | L_Zuluft | 2.07401 | 301 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 40 | 200 | 125 | 133 | L_Abluft | 0.790589 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 42 | 125 | 100 | 64 | L_Abluft | 0.251641 | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 27 | 180 | 125 | 106 | L_Zuluft | 1.51915 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 1 | 315 | 200 | 188 | L_Fortluft | 1.04162 | 7 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 2 | 200 | 315 | 188 | L_Abluft | 5.45279 | 13 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 160 | 200 | 85 | L_Abluft | 1.06053 | 122 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 25 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 60 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 27 | 160 | 200 | 85 | L_Abluft | 1.06053 | 110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 23 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 21 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 118 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 27 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 42 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 20 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 134 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 19 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 144 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 22 | 160 | 200 | 85 | L_Abluft | 1.06053 | 163 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 28 | 160 | 200 | 85 | L_Abluft | 1.06053 | 88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 23 | 160 | 200 | 85 | L_Abluft | 1.06053 | 153 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 22 | 160 | 200 | 85 | L_Zuluft | 0.360125 | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 24 | 160 | 200 | 85 | L_Abluft | 1.06053 | 139 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 20 | 160 | 200 | 85 | L_Abluft | 1.06053 | 196 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 12 | 100 | 160 | 112 | L_Zuluft | 0.720827 | 837 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 10 | 125 | 160 | 78 | L_Zuluft | 0.30291 | 869 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 32 | 125 | 160 | 78 | L_Abluft | 0.90515 | 803 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 169 | 250 | 200 | 99 | L_Zuluft | 0.952794 | 110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 22 | 160 | 125 | 78 | L_Zuluft | 0.458846 | 404 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 31 | 125 | 160 | 78 | L_Abluft | 1.37112 | 403 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 2 | 630 | 450 | 287 | L_Abluft | 7.90831 | 15 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 11 | 140 | 160 | 57 | L_Zuluft | 0.0612886 | 852 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 51 | 125 | 160 | 78 | L_Zuluft | 0.237041 | 482 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 45 | 200 | 315 | 188 | L_Zuluft | 1.04162 | 179 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 26 | 200 | 180 | 57 | L_Zuluft | 0.41671 | 335 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 21 | 160 | 200 | 85 | L_Abluft | 1.06053 | 187 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 36 | 125 | 160 | 78 | L_Zuluft | 0.30291 | 665 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 6 | 630 | 450 | 287 | L_Abluft | 0.208829 | 15 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 6 | 450 | 250 | 310 | L_Abluft | 4.90948 | 17 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 4 | 630 | 450 | 287 | L_Abluft | 2.3382 | 33 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 4 | 450 | 400 | 109 | L_Abluft | 0.907833 | 35 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x Konisches Übergangsstück | EG_Verwaltung_FFB |  | 280 | 200 | 140 | L_Zuluft
3 x Konisches Übergangsstück | EG_Verwaltung_FFB |  | 280 | 200 | 140 | L_Zuluft | 1.70245
3 x Konisches Übergangsstück | EG_Verwaltung_FFB |  | 280 | 200 | 140 | L_Zuluft | 1.64724
3 x Konisches Übergangsstück | EG_Verwaltung_FFB |  | 280 | 200 | 140 | L_Zuluft | 1.63812
Konisches Übergangsstück | EG_Verwaltung_FFB |  | 250 | 200 | 99 | L_Zuluft | 0.947522
2 x Konisches Übergangsstück | EG_Verwaltung_FFB |  | 280 | 200 | 140 | L_Abluft | 2.55957
Konisches Übergangsstück | EG_Verwaltung_FFB |  | 250 | 200 | 99 | L_Zuluft | 0.830318
Konisches Übergangsstück | EG_Verwaltung_FFB | 13 | 100 | 160 | 112 | L_Abluft | 3.24063 | 241 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Konisches Übergangsstück | EG_Verwaltung_FFB | 65 | 125 | 160 | 78 | L_Zuluft | 0.351304 | 340 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: Rohrübergang asymmetrisch (11)
Description: Rohrübergang asymmetrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Additional straight length (mm): 50 mm; Tech-Material (ID): 1; Name: Rohrübergang asymmetrisch; Abbreviation: RA
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Diameter (mm) (mm) | Geom-Offset 1 (mm) (mm) | Geom-Offset 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Rohrübergang asymmetrisch | Wartung_FFB | 56 | 700 | 500 | 630 | 160 | -35 | 500 | 1.25994 | L_Zuluft | 8.06363 | -0.432167 | 131 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 58 | 200 | 175 | 200 | 50 | 0.01 | 300 | 1 | L_Zuluft | 1.0949 | 0.0171918 | 390 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 57 | 200 | 175 | 200 | -50 | 0.01 | 300 | 1 | L_Zuluft | 1.11324 | 0.0171918 | 398 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 27 | 300 | 200 | 200 | 50 | -50 | 300 | 1 | L_Abluft | 1.45986 | 0.483741 | 432 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 13 | 200 | 200 | 180 | 0.01 | -100 | 500 | 1 | L_Zuluft | 1.95802 | 0.46577 | 264 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 10 | 200 | 200 | 160 | 65 | -20 | 300 | 1 | L_Zuluft | 1.22052 | 0.459236 | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 38 | 200 | 200 | 200 | 91.1397 | 0 | 300 | 1 | L_Abluft | 1.20399 | 0.193703 | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB | 7 | 200 | 200 | 200 | 50 | 0 | 300 | 1 | L_Abluft | 1.16789 | 0.21214 | 621 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang asymmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 180 | 0 | -10 | 300 | 1 | L_Abluft | 1.15456
Rohrübergang asymmetrisch | EG_Verwaltung_FFB |  | 250 | 200 | 200 | 100 | -25 | 300 | 1 | L_Abluft | 1.3661
Rohrübergang asymmetrisch | EG_Verwaltung_FFB |  | 350 | 300 | 280 | 50 | -35 | 300 | 1 | L_Zuluft | 1.92228

# IfcFlowFitting: Rohrübergang symmetrisch (92)
Description: Rohrübergang symmetrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Additional straight length (mm): 50 mm; Tech-Material (ID): 1; Name: Rohrübergang symmetrisch; Abbreviation: RS
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Diameter (mm) (mm) | Geom-Offset 1 (mm) (mm) | Geom-Offset 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Rohrübergang symmetrisch | Wartung_FFB | 84 | 300 | 250 | 250 | 0 | -25 | 300 | 1 | L_Zuluft | 1.58949 | 0.291967 | 469 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | Wartung_FFB | 91 | 500 | 700 | 630 | -35 | 65 | 500 | 1.2101 | L_Zuluft | 7.74462 | -0.432167 | 418 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | Wartung_FFB | 118 | 300 | 250 | 250 | 0 | -25 | 300 | 1 | L_Zuluft | 1.58949 | 0.291967 | 281 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | Wartung_FFB | 133 | 500 | 700 | 630 | -35 | 65 | 500 | 1.2101 | L_Zuluft | 7.74462 | -0.432167 | 185 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | Wartung_FFB | 49 | 300 | 250 | 250 | 0 | -25 | 300 | 1 | L_Zuluft | 1.58949 | 0.291967 | 179 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | Wartung_FFB | 22 | 300 | 250 | 250 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.58949 | 0.388714 | 326 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | Wartung_FFB | 31 | 600 | 700 | 630 | -35 | 15 | 500 | 1.30318 | L_Zuluft | 8.34036 | 0.0818705 | 264 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 30 | 250 | 200 | 200 | 0 | -25 | 300 | 1 | L_Abluft | 1.30049 | 0.464169 | 761 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 70 | 250 | 300 | 200 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.60585 | 0.697277 | 371 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 79 | 250 | 300 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.60585 | 2.11587 | 245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 62 | 350 | 200 | 180 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.64635 | 2.32558 | 286 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 85 | 350 | 200 | 180 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.64635 | 0.660348 | 92 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 8 | 200 | 250 | 200 | -25 | 0 | 300 | 1 | L_Zuluft | 1.30049 | 0.237918 | 825 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 8 | 200 | 250 | 200 | -25 | 0 | 300 | 1 | L_Abluft | 1.30049 | 0.453312 | 860 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 55 | 250 | 200 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.30049 | 0.367511 | 408 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 28 | 200 | 200 | 200 | 0 | 0 | 300 | 1 | L_Zuluft | 1.152 | -0.0717059 | 719 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 11 | 250 | 200 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.30049 | 0.287881 | 537 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 17 | 250 | 200 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.30049 | 0.280452 | 452 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 180 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.15264 | 0.096082 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 9 | 200 | 200 | 180 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.15264 | 0.439535 | 592 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 9 | 300 | 350 | 200 | 0.01 | 0.01 | 500 | 1 | L_Zuluft | 3.1549 | 3.76178 | 105 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 9 | 300 | 250 | 200 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.60585 | 0.713398 | 143 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 9 | 200 | 150 | 180 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.00926 | 0.0908159 | 359 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 8 | 200 | 150 | 180 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.00926 | 0.0908159 | 371 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 8 | 200 | 150 | 180 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.00926 | 0.0119036 | 341 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 7 | 200 | 150 | 180 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.00926 | 0.0119036 | 349 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 23 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.15456 | 0.445394 | 143 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 25 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.15456 | 0.421764 | 82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 22 | 200 | 160 | 160 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.0391 | 0.174649 | 119 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 28 | 200 | 160 | 160 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.0391 | 0.303658 | 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 5 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.15456 | 0.498303 | 233 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 6 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.15456 | 0.526222 | 289 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 11 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.15456 | 0.484966 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 19 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.15456 | 0.47857 | 137 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 26 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.15456 | 0.505383 | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 25 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.15456 | 0.47857 | 63 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 20 | 200 | 200 | 160 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.15456 | 0.505383 | 190 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 7 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.00276895 | 524 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 14 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0119114 | 493 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 9 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.00395045 | 517 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 15 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0119114 | 488 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 10 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0118848 | 507 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 16 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.00275614 | 480 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 60 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0270405 | 201 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
2 x Rohrübergang symmetrisch | EG_Verwaltung_FFB | 75 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0270405 | 110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 67 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.012018 | 160 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 46 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0179528 | 297 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 68 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.012018 | 153 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 65 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.012018 | 171 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 39 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0187781 | 342 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 64 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.012018 | 178 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 57 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0270405 | 221 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 59 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0270405 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 42 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0187781 | 328 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 41 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0187781 | 336 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 38 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0187781 | 350 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 45 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0179528 | 305 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
2 x Rohrübergang symmetrisch | EG_Verwaltung_FFB | 76 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0270405 | 102 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 56 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.0270405 | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 168 | 300 | 300 | 250 | -25 | -25 | 300 | 1 | L_Zuluft | 1.73399 | 0.894369 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 49 | 350 | 300 | 200 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.92961 | 4.24597 | 266 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 2 | 600 | 600 | 450 | 0.01 | 0.01 | 200 | 1 | L_Abluft | 3.2809 | 2.27319 | 18 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 26 | 300 | 200 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.45986 | 0.605891 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 37 | 200 | 200 | 125 | -37.5 | -37.5 | 300 | 1 | L_Abluft | 1.16097 | 0.356214 | 329 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 400 | 300 | 280 | -10 | -60 | 500 | 1 | L_Zuluft | 3.38411
2 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 500 | 300 | 280 | -10 | -110 | 500 | 1 | L_Zuluft | 3.93183
2 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 350 | 300 | 280 | -10 | -35 | 300 | 1 | L_Zuluft | 1.8847 | 0.534418
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 57 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.014837 | 221 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
Rohrübergang symmetrisch | EG_Verwaltung_FFB | 56 | 200 | 400 | 325 | 0.01 | 0.01 | 250 | 1 | L_Abluft | 1.48432 | 0.014837 | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Info: nur Berechnung
5 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 300 | 350 | 280 | -35 | -10 | 300 | 1 | L_Zuluft | 1.8847 | 0.515655
Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 300 | 300 | 250 | -25 | -25 | 300 | 1 | L_Zuluft | 1.73399 | 0.894369
Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 300 | 350 | 250 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.89782 | 1.64129
3 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 250 | 300 | 200 | 0.01 | 0.01 | 300 | 1 | L_Abluft | 1.60585 | 2.26431
3 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 250 | 200 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.30049
2 x Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 250 | 300 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.60585
Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 350 | 200 | 200 | 0.01 | 0.01 | 300 | 1 | L_Zuluft | 1.63275
Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 200 | 400 | 325 | -37.5 | 62.5 | 250 | 1 | L_Abluft | 1.48432 | 0.0118848
Rohrübergang symmetrisch | EG_Verwaltung_FFB |  | 350 | 200 | 140 | -30 | -105 | 350 | 1 | L_Abluft | 1.92937

# IfcFlowFitting: Segeltuchstutzen (28)
In: Wartung_FFB
Description: Segeltuchstutzen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 60 mm; Calc-Zeta: 2; Name: Segeltuchstutzen; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No.
Segeltuchstutzen | 93 | 918 | 1530 | L_Aussenluft | 4.87367 | 881
Segeltuchstutzen | 1 | 918 | 1530 | L_Zuluft | 4.80694 | 3
Segeltuchstutzen | 1 | 918 | 1530 | L_Fortluft | 4.87367 | 4
Segeltuchstutzen | 2 | 1530 | 918 | L_Abluft | 4.87367 | 32
Segeltuchstutzen | 28 | 612 | 918 | L_Aussenluft | 3.1946 | 262
Segeltuchstutzen | 1 | 612 | 918 | L_Zuluft | 3.1946 | 3
Segeltuchstutzen | 1 | 612 | 918 | L_Fortluft | 3.1946 | 4
Segeltuchstutzen | 2 | 918 | 612 | L_Abluft | 3.1946 | 40
Segeltuchstutzen | 2 | 612 | 612 | L_Zuluft | 4.22485 | 52
Segeltuchstutzen | 1 | 612 | 612 | L_Aussenluft | 4.22485 | 11
Segeltuchstutzen | 1 | 612 | 612 | L_Abluft | 4.42762 | 6
Segeltuchstutzen | 30 | 612 | 612 | L_Fortluft | 4.22485 | 364
Segeltuchstutzen | 1 | 612 | 918 | L_Zuluft | 3.63474 | 3
Segeltuchstutzen | 17 | 612 | 918 | L_Aussenluft | 3.63474 | 126
Segeltuchstutzen | 1 | 612 | 918 | L_Fortluft | 3.63474 | 4
Segeltuchstutzen | 2 | 612 | 918 | L_Abluft | 3.63474 | 34
Segeltuchstutzen | 1 | 612 | 918 | L_Zuluft | 6.39767 | 3
Segeltuchstutzen | 2 | 612 | 918 | L_Abluft | 6.23433 | 37
Segeltuchstutzen | 53 | 612 | 918 | L_Aussenluft | 4.97946 | 571
Segeltuchstutzen | 1 | 612 | 918 | L_Fortluft | 4.97946 | 3
Segeltuchstutzen | 193 | 2448 | 2448 | L_Aussenluft | 5.43195 | 652
Segeltuchstutzen | 1 | 2448 | 2448 | L_Abluft | 2.88675 | 9
Segeltuchstutzen | 1 | 2448 | 2448 | L_Zuluft | 3.19206 | 4
Segeltuchstutzen | 81 | 2448 | 2448 | L_Fortluft | 4.52646 | 527
Segeltuchstutzen | 1 | 2142 | 2448 | L_Zuluft | 3.22058 | 4
Segeltuchstutzen | 8 | 2142 | 2448 | L_Aussenluft | 3.5789 | 77
Segeltuchstutzen | 4 | 2142 | 2448 | L_Abluft | 3.62295 | 52
Segeltuchstutzen | 1 | 2142 | 2448 | L_Fortluft | 3.5789 | 5

# IfcFlowFitting: Segmentbogen 2 teilig
In: EG_Verwaltung_FFB
Description: Segmentbogen 2 teilig
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 2; Geom-Diameter (mm): 630 mm; Geom-Angle (°): 15 rad; Geom-Radius (mm): 630 mm; Geom-Number of segments (if segmented): 2; Tech-Medium: L_Abluft; Tech-Material (ID): 1; Calc-Pressure loss (Pa): 1.23492 Pa; Name: Segmentbogen 2 teilig; Pos. No.: 13; Abbreviation: BSE; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: Segmentbogen 3 teilig (4)
In: Wartung_FFB
Description: Segmentbogen 3 teilig
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 133; Geom-Diameter (mm): 630 mm; Geom-Angle (°): 45 rad; Geom-Radius (mm): 630 mm; Geom-Number of segments (if segmented): 3; Tech-Medium: L_Zuluft; Tech-Material (ID): 1; Calc-Pressure loss (Pa): 3.52372 Pa; Name: Segmentbogen 3 teilig; Abbreviation: BSE; Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
Segmentbogen 3 teilig | 193
Segmentbogen 3 teilig | 191
Segmentbogen 3 teilig | 189
Segmentbogen 3 teilig | 187

# IfcFlowFitting: Segmentbogen 4 teilig (8)
Description: Segmentbogen 4 teilig
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 90 rad; Geom-Number of segments (if segmented): 4; Tech-Material (ID): 1; Name: Segmentbogen 4 teilig; Abbreviation: BSE; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Section No | Geom-Diameter (mm) (mm) = Geom-Radius (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No.
Segmentbogen 4 teilig | Wartung_FFB | 91 | 630 | L_Zuluft | 4.40465 | 424 | Wartung_FFB | 2
Segmentbogen 4 teilig | Wartung_FFB | 133 | 630 | L_Zuluft | 4.40465 | 197 | Wartung_FFB | 2
Segmentbogen 4 teilig | Wartung_FFB | 56 | 630 | L_Zuluft | 4.40465 | 137 | Wartung_FFB | 2
Segmentbogen 4 teilig | Wartung_FFB | 31 | 630 | L_Zuluft | 4.40465 | 270 | Wartung_FFB | 2
Segmentbogen 4 teilig | Wartung_FFB | 1 | 630 | L_Abluft | 5.95545 | 9 | Wartung_FFB | 2
Segmentbogen 4 teilig | Wartung_FFB | 1 | 630 | L_Abluft | 5.95545 | 7 | Wartung_FFB | 2
Segmentbogen 4 teilig | EG_Verwaltung_FFB | 2 | 630 | L_Abluft | 3.81149 | 11 | EG_Verwaltung_FFB | 0
Segmentbogen 4 teilig | EG_Verwaltung_FFB | 2 | 450 | L_Abluft | 14.6422 | 17 | EG_Verwaltung_FFB | 0

# IfcFlowFitting: T-Stück oben gerade (66)
Description: T-Stück oben gerade
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Offnet (mm): 0 mm; Tech-Material (ID): 1; Name: T-Stück oben gerade; Abbreviation: TG
Name | In | Section No | Geom-Thickness (mm) (mm) | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Side 3 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Branch length (mm) (mm) | Geom-Distance to branch (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Pos. No. | Floor | Floor No. | Building = Building No.
T-Stück oben gerade | Wartung_FFB | 4 | 1200 | 1500 | 1500 | 2000 | 2300 | 150 | 150 | 13.38 | L_Abluft | 107.04 | 64 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 80 | 500 | 800 | 350 | 700 | 1000 | 600 | 150 | 4.04 | L_Zuluft | 25.856 | 417 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 112 | 500 | 700 | 400 | 700 | 1000 | 450 | 150 | 3.48 | L_Zuluft | 22.272 | 184 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 72 | 700 | 800 | 800 | 1500 | 1800 | 150 | 150 | 6.06 | L_Zuluft | 48.48 | 90 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 1 | 1400 | 1500 | 1500 | 1500 | 1800 | 150 | 150 | 11.31 | L_Zuluft | 90.48 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 10 | 800 | 800 | 800 | 1500 | 1800 | 150 | 150 | 6.45 | L_Zuluft | 51.6 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 45 | 500 | 800 | 350 | 700 | 1000 | 600 | 150 | 4.04 | L_Zuluft | 25.856 | 130 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 17 | 600 | 800 | 400 | 700 | 1000 | 550 | 150 | 4.23 | L_Zuluft | 27.072 | 263 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 1 | 1800 | 2000 | 1200 | 1400 | 1700 | 950 | 150 | 19 | L_Zuluft | 152 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 33 | 1300 | 1300 | 1400 | 500 | 800 | 150 | 150 | 5.22 | L_Zuluft | 41.76 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 37 | 1000 | 450 | 800 | 400 | 700 | 150 | 150 | 3.92 | L_Zuluft | 25.088 | 341 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 3 | 500 | 700 | 1200 | 600 | 900 | 150 | 150 | 4.49 | L_Abluft | 35.92 | 360 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 170 | 500 | 1500 | 700 | 600 | 900 | 950 | 150 | 5.69 | L_Zuluft | 45.52 | 174 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 1 | 1600 | 1800 | 1400 | 1000 | 1300 | 550 | 150 | 11.7 | L_Abluft | 93.6 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB | 2 | 1000 | 1400 | 1200 | 800 | 1100 | 350 | 150 | 6.54 | L_Abluft | 52.32 | 233 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | Wartung_FFB |  | 500 | 600 | 400 | 300 | 600 | 350 | 150 | 1.88 | L_Abluft | 12.032
T-Stück oben gerade | Wartung_FFB |  | 500 | 600 | 350 | 350 | 650 | 400 | 150 | 2.11 | L_Zuluft | 13.504
T-Stück oben gerade | EG_Verwaltung_FFB | 60 | 500 | 350 | 550 | 650 | 950 | 150 | 150 | 2.8 | L_Zuluft | 17.92 | 38 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 61 | 500 | 550 | 350 | 650 | 950 | 350 | 150 | 2.8 | L_Abluft | 17.92 | 62 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 54 | 250 | 200 | 350 | 400 | 700 | 150 | 150 | 1.23 | L_Zuluft | 5.904 | 386 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 4 | 450 | 450 | 700 | 600 | 900 | 150 | 150 | 2.91 | L_Zuluft | 18.624 | 419 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 3 | 700 | 450 | 200 | 600 | 900 | 400 | 150 | 3.11 | L_Zuluft | 19.904 | 381 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 4 | 700 | 450 | 450 | 600 | 900 | 150 | 150 | 2.46 | L_Abluft | 15.744 | 414 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 17 | 300 | 250 | 200 | 500 | 700 | 150 | 100 | 1.01 | L_Abluft | 4.848 | 431 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 8 | 300 | 200 | 200 | 500 | 700 | 100 | 100 | 1 | L_Zuluft | 4.128 | 434 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 6 | 200 | 200 | 200 | 350 | 650 | 150 | 150 | 1 | L_Abluft | 3.288 | 571 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 5 | 600 | 400 | 400 | 500 | 800 | 150 | 150 | 1.93 | L_Abluft | 12.352 | 188 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 4 | 300 | 200 | 200 | 350 | 650 | 150 | 150 | 1 | L_Abluft | 4.056 | 206 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 21 | 200 | 160 | 300 | 400 | 700 | 150 | 150 | 1.048 | L_Abluft | 5.0304 | 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 20 | 200 | 300 | 400 | 160 | 460 | 150 | 150 | 1 | L_Zuluft | 3.5136 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 2 | 500 | 250 | 300 | 500 | 800 | 150 | 150 | 1.68 | L_Zuluft | 8.064 | 24 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 3 | 500 | 300 | 300 | 500 | 800 | 150 | 150 | 1.58 | L_Abluft | 7.584 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 3 | 250 | 200 | 300 | 400 | 700 | 150 | 150 | 1.095 | L_Zuluft | 5.256 | 150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 4 | 300 | 200 | 300 | 500 | 800 | 150 | 150 | 1.36 | L_Abluft | 6.528 | 200 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 191 | 400 | 300 | 300 | 450 | 650 | 100 | 100 | 1.08 | L_Zuluft | 5.184 | 331 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 172 | 500 | 500 | 450 | 700 | 1000 | 200 | 150 | 2.48 | L_Zuluft | 15.872 | 325 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 173 | 500 | 300 | 300 | 500 | 800 | 150 | 150 | 1.58 | L_Zuluft | 7.584 | 359 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 5 | 700 | 400 | 400 | 500 | 800 | 150 | 150 | 2.12 | L_Abluft | 13.568 | 471 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 12 | 400 | 350 | 200 | 700 | 1000 | 300 | 150 | 2.16 | L_Abluft | 13.824 | 473 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 6 | 400 | 200 | 450 | 700 | 1000 | 150 | 150 | 2.58 | L_Abluft | 16.512 | 495 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 20 | 350 | 300 | 300 | 500 | 800 | 150 | 150 | 1.295 | L_Zuluft | 6.216 | 555 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 74 | 300 | 400 | 650 | 400 | 700 | 150 | 150 | 1.89 | L_Abluft | 12.096 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 70 | 800 | 350 | 350 | 500 | 800 | 150 | 150 | 2.23 | L_Abluft | 14.272 | 96 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 63 | 300 | 400 | 500 | 400 | 700 | 150 | 150 | 1.47 | L_Abluft | 7.056 | 168 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 66 | 300 | 400 | 500 | 400 | 700 | 150 | 150 | 1.47 | L_Abluft | 7.056 | 150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 62 | 700 | 300 | 300 | 400 | 700 | 150 | 150 | 1.73 | L_Abluft | 11.072 | 147 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 58 | 300 | 400 | 650 | 400 | 700 | 100 | 150 | 1.82 | L_Abluft | 11.648 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 54 | 800 | 300 | 300 | 500 | 800 | 150 | 150 | 2.15 | L_Abluft | 13.76 | 194 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 55 | 300 | 400 | 650 | 400 | 700 | 150 | 150 | 1.89 | L_Abluft | 12.096 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 36 | 400 | 550 | 550 | 800 | 1100 | 150 | 150 | 2.45 | L_Abluft | 15.68 | 322 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 44 | 550 | 200 | 200 | 300 | 600 | 150 | 150 | 1.155 | L_Abluft | 7.392 | 290 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 5 | 300 | 300 | 300 | 350 | 650 | 150 | 150 | 1 | L_Zuluft | 4.68 | 242 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 36 | 200 | 200 | 200 | 200 | 500 | 150 | 150 | 1 | L_Abluft | 2.496 | 225 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
T-Stück oben gerade | EG_Verwaltung_FFB | 33 | 350 | 200 | 200 | 200 | 400 | 50 | 100 | 1 | L_Abluft | 2.376 | 196 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x T-Stück oben gerade | EG_Verwaltung_FFB |  | 450 | 500 | 450 | 800 | 1100 | 200 | 150 | 2.59 | L_Zuluft | 16.576
T-Stück oben gerade | EG_Verwaltung_FFB |  | 300 | 500 | 400 | 400 | 700 | 250 | 150 | 1.47 | L_Abluft | 7.056
T-Stück oben gerade | EG_Verwaltung_FFB |  | 350 | 650 | 800 | 400 | 700 | 150 | 150 | 2.06 | L_Abluft | 13.184
2 x T-Stück oben gerade | EG_Verwaltung_FFB | 58 | 300 | 400 | 550 | 400 | 700 | 150 | 150 | 1.61 | L_Abluft | 10.304 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
