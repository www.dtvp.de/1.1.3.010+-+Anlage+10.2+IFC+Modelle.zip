Properties of the parts of a building model (IFC2X3), part 15 of 18

# IfcFlowSegment: Wickelfalzrohr (1462)
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 125 | 178.316 | L_Zuluft | 130 | 2.9426 | 0.202655 | 273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 6000 | L_Zuluft | 220 | 3.03942 | 5.3033 | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 340.228 | L_Zuluft | 220 | 3.03942 | 0.300721 | 281 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 180 | 2799.34 | L_Zuluft | 350 | 3.82059 | 3.25281 | 267 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 125 | 238.257 | L_Zuluft | 110 | 2.48989 | 0.199728 | 255 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 125 | 238.257 | L_Abluft | 110 | 2.48989 | 0.199728 | 216 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 125 | 936.85 | L_Zuluft | 110 | 2.48989 | 0.785352 | 253 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 127.094 | L_Zuluft | 160 | 3.62166 | 0.211377 | 200 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 125 | 127.094 | L_Abluft | 160 | 3.62166 | 0.211377 | 163 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 868.169 | L_Zuluft | 160 | 3.62166 | 1.4439 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 125 | 838.943 | L_Abluft | 160 | 3.62166 | 1.39529 | 166 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 180 | 6000 | L_Zuluft | 320 | 3.49311 | 5.90945 | 194 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 180 | 6000 | L_Zuluft | 320 | 3.49311 | 5.90945 | 193 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 180 | 6000 | L_Zuluft | 320 | 3.49311 | 5.90945 | 192 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 180 | 6000 | L_Abluft | 320 | 3.49311 | 5.90945 | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 180 | 6000 | L_Abluft | 320 | 3.49311 | 5.90945 | 156 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 180 | 6000 | L_Abluft | 320 | 3.49311 | 5.90945 | 155 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 1651.45 | L_Zuluft | 160 | 3.62166 | 2.74663 | 213 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 1344.86 | L_Abluft | 160 | 3.62166 | 2.23671 | 176 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 1606.01 | L_Zuluft | 160 | 3.62166 | 2.67106 | 217 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 397.429 | L_Zuluft | 160 | 3.62166 | 0.660986 | 222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 262.008 | L_Zuluft | 160 | 3.62166 | 0.43576 | 219 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 1606.01 | L_Abluft | 160 | 3.62166 | 2.67106 | 180 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 262.008 | L_Abluft | 160 | 3.62166 | 0.43576 | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 405.851 | L_Abluft | 160 | 3.62166 | 0.674994 | 185 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 6000 | L_Abluft | 160 | 3.62166 | 9.97895 | 172 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 6000 | L_Abluft | 160 | 3.62166 | 9.97895 | 173 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 4139.63 | L_Abluft | 160 | 3.62166 | 6.88485 | 174 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 6000 | L_Zuluft | 160 | 3.62166 | 9.97895 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 6000 | L_Zuluft | 160 | 3.62166 | 9.97895 | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 4758.23 | L_Zuluft | 160 | 3.62166 | 7.91369 | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 180 | 2295.32 | L_Zuluft | 320 | 3.49311 | 2.26068 | 191 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 180 | 3238.93 | L_Abluft | 320 | 3.49311 | 3.19005 | 154 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 180 | 5358.5 | L_Abluft | 410 | 4.47555 | 8.34741 | 225 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 125 | 1336.85 | L_Abluft | 110 | 2.48989 | 1.12067 | 214 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 100 | 143.082 | L_Abluft | 60 | 2.12207 | 0.119232 | 251 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 100 | 99.9983 | L_Abluft | 60 | 2.12207 | 0.0833295 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 100 | 617.049 | L_Abluft | 60 | 2.12207 | 0.514192 | 253 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 100 | 1483.72 | L_Abluft | 60 | 2.12207 | 1.2364 | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 125 | 451.374 | L_Abluft | 220 | 4.97978 | 1.35336 | 259 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 125 | 2206.23 | L_Abluft | 220 | 4.97978 | 6.61495 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 295.986 | L_Zuluft | 220 | 3.03942 | 0.261617 | 289 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 180 | 131.616 | L_Zuluft | 315 | 3.43853 | 0.125924 | 360 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 8 | 180 | 131.616 | L_Zuluft | 315 | 3.43853 | 0.125924 | 372 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 180 | 236.407 | L_Zuluft | 315 | 3.43853 | 0.226183 | 362 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 8 | 180 | 2869.68 | L_Zuluft | 315 | 3.43853 | 2.74557 | 374 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 180 | 131.616 | L_Abluft | 315 | 3.43853 | 0.125924 | 350 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 8 | 180 | 131.616 | L_Abluft | 315 | 3.43853 | 0.125924 | 342 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 180 | 236.407 | L_Abluft | 315 | 3.43853 | 0.226183 | 352 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 180 | 345.496 | L_Abluft | 315 | 3.43853 | 0.330554 | 357 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 180 | 345.496 | L_Zuluft | 315 | 3.43853 | 0.330554 | 367 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 8 | 180 | 2869.68 | L_Abluft | 315 | 3.43853 | 2.74557 | 344 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 100 | 277.5 | L_Zuluft | 60 | 2.12207 | 0.231243 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 100 | 296.697 | L_Zuluft | 60 | 2.12207 | 0.24724 | 336 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 1380.38 | L_Zuluft | 60 | 2.12207 | 1.15028 | 346 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 306.697 | L_Zuluft | 60 | 2.12207 | 0.255573 | 351 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 693.956 | L_Abluft | 60 | 2.12207 | 0.57828 | 316 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 100 | 251.456 | L_Abluft | 60 | 2.12207 | 0.209541 | 328 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 100 | 693.956 | L_Abluft | 60 | 2.12207 | 0.57828 | 333 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 125 | 618.164 | L_Abluft | 110 | 2.48989 | 0.518201 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 125 | 551.803 | L_Abluft | 110 | 2.48989 | 0.462571 | 212 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 100 | 863.81 | L_Abluft | 90 | 3.1831 | 1.50317 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 734.296 | L_Zuluft | 230 | 3.17757 | 0.704156 | 147 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 100 | 336.382 | L_Zuluft | 90 | 3.1831 | 0.585361 | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 100 | 858.277 | L_Abluft | 90 | 3.1831 | 1.49355 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 160 | 715.329 | L_Abluft | 275 | 3.79927 | 0.953125 | 63 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 160 | 823.012 | L_Abluft | 275 | 3.79927 | 1.09661 | 59 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 265.584 | L_Abluft | 275 | 3.79927 | 0.353871 | 77 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 2895.07 | L_Abluft | 275 | 3.79927 | 3.85748 | 75 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 125 | 2812.98 | L_Abluft | 140 | 3.16895 | 3.66115 | 103 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 125 | 201.59 | L_Abluft | 140 | 3.16895 | 0.262373 | 110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 125 | 461.347 | L_Abluft | 140 | 3.16895 | 0.600452 | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 125 | 2573.68 | L_Zuluft | 140 | 3.16895 | 3.34971 | 165 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 125 | 201.59 | L_Zuluft | 140 | 3.16895 | 0.262373 | 172 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 125 | 568.368 | L_Zuluft | 140 | 3.16895 | 0.739743 | 175 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 858.134 | L_Zuluft | 275 | 3.79927 | 1.1434 | 138 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 423.012 | L_Zuluft | 275 | 3.79927 | 0.563634 | 134 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 307.235 | L_Abluft | 220 | 3.03942 | 0.27156 | 122 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 881.237 | L_Abluft | 220 | 3.03942 | 0.77891 | 124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 307.225 | L_Abluft | 220 | 3.03942 | 0.271551 | 126 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 6000 | L_Abluft | 220 | 3.03942 | 5.3033 | 129 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 157.414 | L_Zuluft | 275 | 3.79927 | 0.209743 | 118 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 373.012 | L_Zuluft | 275 | 3.79927 | 0.497012 | 114 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 6000 | L_Zuluft | 220 | 3.03942 | 5.3033 | 92 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 1164.67 | L_Abluft | 220 | 3.03942 | 1.02943 | 130 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 1318.53 | L_Zuluft | 220 | 3.03942 | 1.16542 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 191.557 | L_Zuluft | 220 | 3.03942 | 0.169314 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 277.25 | L_Zuluft | 220 | 3.03942 | 0.245056 | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 124.461 | L_Zuluft | 250 | 3.45388 | 0.139117 | 224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 182.629 | L_Zuluft | 250 | 3.45388 | 0.204134 | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 178.537 | L_Zuluft | 250 | 3.45388 | 0.19956 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 160 | 124.461 | L_Abluft | 250 | 3.45388 | 0.139117 | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 160 | 128.116 | L_Abluft | 250 | 3.45388 | 0.143202 | 283 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 2299.58 | L_Zuluft | 250 | 3.45388 | 2.57036 | 238 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 361.041 | L_Zuluft | 250 | 3.45388 | 0.403555 | 240 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 160 | 100.378 | L_Abluft | 240 | 3.31573 | 0.104083 | 267 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 160 | 643.49 | L_Abluft | 240 | 3.31573 | 0.667243 | 264 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 264.269 | L_Abluft | 250 | 3.45388 | 0.295388 | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 205.943 | L_Abluft | 250 | 3.45388 | 0.230193 | 290 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 1062.41 | L_Abluft | 250 | 3.45388 | 1.18752 | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 160 | 202.874 | L_Abluft | 250 | 3.45388 | 0.226764 | 256 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 160 | 4048.68 | L_Zuluft | 250 | 3.45388 | 4.52543 | 201 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 160 | 187.02 | L_Abluft | 250 | 3.45388 | 0.209042 | 254 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 160 | 180.967 | L_Zuluft | 250 | 3.45388 | 0.202277 | 186 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 160 | 173.205 | L_Zuluft | 250 | 3.45388 | 0.193601 | 184 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 160 | 1032.09 | L_Zuluft | 250 | 3.45388 | 1.15362 | 199 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 180.967 | L_Abluft | 250 | 3.45388 | 0.202277 | 215 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 252.514 | L_Zuluft | 100 | 3.53678 | 0.533012 | 169 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 234.651 | L_Zuluft | 100 | 3.53678 | 0.495307 | 166 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 693.483 | L_Zuluft | 100 | 3.53678 | 1.46382 | 164 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 234.651 | L_Abluft | 100 | 3.53678 | 0.495307 | 235 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 335.775 | L_Abluft | 100 | 3.53678 | 0.708762 | 238 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 411.918 | L_Abluft | 100 | 3.53678 | 0.869487 | 233 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 159.583 | L_Abluft | 40 | 1.41471 | 0.0643408 | 320 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 159.583 | L_Zuluft | 40 | 1.41471 | 0.0643408 | 326 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 892.073 | L_Zuluft | 40 | 1.41471 | 0.359668 | 328 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 154.667 | L_Zuluft | 40 | 1.41471 | 0.0623588 | 330 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 88 | L_Zuluft | 40 | 1.41471 | 0.03548 | 332 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 657.927 | L_Abluft | 40 | 1.41471 | 0.265264 | 325 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 88 | L_Abluft | 40 | 1.41471 | 0.03548 | 327 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 159.583 | L_Abluft | 40 | 1.41471 | 0.0643408 | 304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 159.583 | L_Zuluft | 40 | 1.41471 | 0.0643408 | 310 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 154.667 | L_Zuluft | 40 | 1.41471 | 0.0623588 | 314 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 182.454 | L_Zuluft | 40 | 1.41471 | 0.0735623 | 312 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 246.541 | L_Abluft | 40 | 1.41471 | 0.0994011 | 306 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 95 | L_Abluft | 40 | 1.41471 | 0.0383023 | 308 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 272.097 | L_Zuluft | 40 | 1.41471 | 0.109705 | 263 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 100 | 629.953 | L_Zuluft | 80 | 2.82942 | 0.884178 | 302 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 100 | 128.573 | L_Abluft | 60 | 2.12207 | 0.107141 | 286 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 100 | 482.828 | L_Abluft | 60 | 2.12207 | 0.402345 | 289 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 200 | 1228.1 | L_Abluft | 390 | 3.44836 | 1.03568 | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 125 | 662.117 | L_Abluft | 140 | 3.16895 | 0.861759 | 279 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 125 | 893.903 | L_Abluft | 180 | 4.07437 | 1.84739 | 262 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 100 | 1125.17 | L_Abluft | 80 | 2.82942 | 1.57925 | 295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 100 | 140 | L_Abluft | 40 | 1.41471 | 0.0564455 | 264 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 124.974 | L_Zuluft | 40 | 1.41471 | 0.0503873 | 286 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 160 | 1108.08 | L_Zuluft | 180 | 2.4868 | 0.678877 | 269 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 160 | 994.488 | L_Zuluft | 120 | 1.65786 | 0.29266 | 284 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 100 | 188.555 | L_Zuluft | 60 | 2.12207 | 0.157125 | 277 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 100 | 316.266 | L_Zuluft | 60 | 2.12207 | 0.263547 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 100 | 649.75 | L_Abluft | 60 | 2.12207 | 0.541442 | 281 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 290.95 | L_Abluft | 40 | 1.41471 | 0.117306 | 312 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 1590.28 | L_Zuluft | 40 | 1.41471 | 0.641173 | 318 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 195.229 | L_Abluft | 40 | 1.41471 | 0.0787126 | 235 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 195.229 | L_Zuluft | 40 | 1.41471 | 0.0787126 | 256 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 100 | 519.193 | L_Abluft | 40 | 1.41471 | 0.209329 | 266 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 100 | 195.229 | L_Abluft | 40 | 1.41471 | 0.0787126 | 268 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 195.229 | L_Zuluft | 40 | 1.41471 | 0.0787126 | 290 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 195.229 | L_Abluft | 40 | 1.41471 | 0.0787126 | 318 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 195.229 | L_Zuluft | 40 | 1.41471 | 0.0787126 | 324 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 140 | 927.532 | L_Zuluft | 210 | 3.7894 | 1.45408 | 243 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 140 | 6000 | L_Abluft | 210 | 3.7894 | 9.40613 | 252 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 140 | 1958.95 | L_Abluft | 210 | 3.7894 | 3.07103 | 253 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 1613.14 | L_Zuluft | 40 | 1.41471 | 0.65039 | 308 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 6000 | L_Abluft | 40 | 1.41471 | 2.41909 | 301 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 1455.71 | L_Abluft | 40 | 1.41471 | 0.586916 | 302 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 437.42 | L_Abluft | 235 | 3.24665 | 0.436359 | 192 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 454.549 | L_Abluft | 235 | 3.24665 | 0.453446 | 194 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 671.826 | L_Zuluft | 235 | 3.24665 | 0.670195 | 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 454.549 | L_Zuluft | 235 | 3.24665 | 0.453446 | 52 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 630 | 1070 | L_Abluft | 4000 | 3.5644 | 0.233706 | 10 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 1 | 315 | 750 | L_Fortluft | 530 | 1.88913 | 0.11963 | 8 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 1 | 200 | 400 | L_Fortluft | 530 | 4.68623 | 0.595331 | 6 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 1 | 200 | 400 | L_Fortluft | 530 | 4.68623 | 0.595331 | 4 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 1 | 200 | 400 | L_Fortluft | 530 | 4.68623 | 0.595331 | 2 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 200 | 931.243 | L_Abluft | 530 | 4.68623 | 1.386 | 10 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 200 | 345 | L_Abluft | 530 | 4.68623 | 0.513473 | 12 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 315 | 300 | L_Abluft | 530 | 1.88913 | 0.047852 | 14 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 295 | L_Zuluft | 130 | 2.9426 | 0.335265 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 310 | L_Zuluft | 170 | 3.84801 | 0.576503 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 320 | L_Zuluft | 170 | 3.84801 | 0.5951 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 178.013 | L_Zuluft | 245 | 3.38481 | 0.191715 | 58 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 224.677 | L_Abluft | 245 | 3.38481 | 0.241972 | 119 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 160 | 224.677 | L_Zuluft | 245 | 3.38481 | 0.241972 | 69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 178.013 | L_Abluft | 245 | 3.38481 | 0.191715 | 108 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 135 | L_Abluft | 245 | 3.38481 | 0.145392 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 162.359 | L_Zuluft | 245 | 3.38481 | 0.174856 | 116 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 160 | 504.538 | L_Zuluft | 245 | 3.38481 | 0.543375 | 131 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 160 | 162.359 | L_Zuluft | 245 | 3.38481 | 0.174856 | 142 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 162.359 | L_Abluft | 245 | 3.38481 | 0.174856 | 161 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 374.826 | L_Abluft | 245 | 3.38481 | 0.403678 | 86 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 1661.95 | L_Zuluft | 245 | 3.38481 | 1.78988 | 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 1765 | L_Zuluft | 245 | 3.38481 | 1.90086 | 38 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 5340.43 | L_Abluft | 245 | 3.38481 | 5.7515 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 1074.18 | L_Abluft | 245 | 3.38481 | 1.15687 | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 259.382 | L_Zuluft | 245 | 3.38481 | 0.279348 | 98 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 6000 | L_Zuluft | 245 | 3.38481 | 6.46185 | 88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 1232.84 | L_Zuluft | 245 | 3.38481 | 1.32774 | 87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 259.382 | L_Zuluft | 245 | 3.38481 | 0.279348 | 85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 357.904 | L_Zuluft | 245 | 3.38481 | 0.385454 | 96 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 357.904 | L_Zuluft | 245 | 3.38481 | 0.385454 | 83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 160 | 759.012 | L_Abluft | 245 | 3.38481 | 0.817437 | 135 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 160 | 3650.89 | L_Abluft | 245 | 3.38481 | 3.93191 | 133 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 160 | 5418.04 | L_Abluft | 245 | 3.38481 | 5.8351 | 194 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 125 | 102.291 | L_Zuluft | 115 | 2.60307 | 0.0929671 | 597 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 125 | 630.05 | L_Zuluft | 115 | 2.60307 | 0.572623 | 595 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 180 | 4732.51 | L_Abluft | 325 | 3.54769 | 4.79619 | 525 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 100 | 555.05 | L_Abluft | 80 | 2.82942 | 0.779048 | 504 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 54 | 100 | 234.242 | L_Abluft | 85 | 3.00626 | 0.367204 | 494 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 54 | 100 | 555.05 | L_Abluft | 85 | 3.00626 | 0.870112 | 492 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 555.05 | L_Zuluft | 80 | 2.82942 | 0.779048 | 454 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 125 | 530.05 | L_Zuluft | 120 | 2.71624 | 0.520537 | 436 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 125 | 2864.03 | L_Zuluft | 120 | 2.71624 | 2.81263 | 438 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 56 | 125 | 2264.03 | L_Abluft | 120 | 2.71624 | 2.2234 | 460 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 56 | 125 | 530.05 | L_Abluft | 120 | 2.71624 | 0.520537 | 458 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 100 | 555.05 | L_Abluft | 60 | 2.12207 | 0.462528 | 470 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 190.767 | L_Zuluft | 435 | 3.84624 | 0.196809 | 796 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 206.525 | L_Zuluft | 435 | 3.84624 | 0.213066 | 781 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 266.746 | L_Zuluft | 435 | 3.84624 | 0.275194 | 784 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 332.845 | L_Zuluft | 435 | 3.84624 | 0.343387 | 786 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 2628.82 | L_Zuluft | 435 | 3.84624 | 2.71208 | 773 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 483.376 | L_Zuluft | 435 | 3.84624 | 0.498685 | 775 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 3257.33 | L_Zuluft | 435 | 3.84624 | 3.3605 | 779 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 3257.33 | L_Zuluft | 435 | 3.84624 | 3.3605 | 771 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 59 | 200 | 345.207 | L_Abluft | 435 | 3.84624 | 0.35614 | 424 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 59 | 200 | 57.5258 | L_Abluft | 435 | 3.84624 | 0.0593477 | 418 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 1819.4 | L_Zuluft | 210 | 3.7894 | 2.85226 | 811 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 506.345 | L_Zuluft | 210 | 3.7894 | 0.793791 | 813 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 3063.42 | L_Zuluft | 210 | 3.7894 | 4.80248 | 815 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 953.161 | L_Zuluft | 110 | 3.89045 | 2.39747 | 830 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 200 | L_Abluft | 440 | 3.89045 | 0.210742 | 48 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 200 | L_Zuluft | 440 | 3.89045 | 0.210742 | 26 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 200 | L_Zuluft | 440 | 3.89045 | 0.210742 | 13 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 6000 | L_Zuluft | 440 | 3.89045 | 6.32227 | 30 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 6000 | L_Zuluft | 440 | 3.89045 | 6.32227 | 29 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 472.787 | L_Zuluft | 440 | 3.89045 | 0.498181 | 28 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 4189.81 | L_Zuluft | 440 | 3.89045 | 4.41486 | 44 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 236.546 | L_Abluft | 440 | 3.89045 | 0.249251 | 77 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 350 | L_Zuluft | 440 | 3.89045 | 0.368799 | 56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 140 | 85 | L_Abluft | 190 | 3.42851 | 0.110826 | 494 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 140 | 1599.35 | L_Abluft | 195 | 3.51873 | 2.18732 | 558 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 140 | 838.614 | L_Abluft | 195 | 3.51873 | 1.14691 | 560 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 140 | 1021.29 | L_Abluft | 195 | 3.51873 | 1.39674 | 562 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 140 | 3728 | L_Zuluft | 195 | 3.51873 | 5.09852 | 557 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 140 | 85 | L_Zuluft | 190 | 3.42851 | 0.110826 | 496 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 63 | 100 | 493.983 | L_Zuluft | 40 | 1.41471 | 0.199165 | 351 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 160 | 940.657 | L_Zuluft | 235 | 3.24665 | 0.938374 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 160 | 525.682 | L_Abluft | 235 | 3.24665 | 0.524406 | 181 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 160 | 1609.42 | L_Zuluft | 235 | 3.24665 | 1.60552 | 272 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 376.096 | L_Abluft | 235 | 3.24665 | 0.375183 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 540.716 | L_Abluft | 110 | 3.89045 | 1.36006 | 875 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 806.756 | L_Zuluft | 110 | 3.89045 | 2.02922 | 834 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 480.287 | L_Zuluft | 110 | 3.89045 | 1.20806 | 836 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 696.038 | L_Zuluft | 210 | 3.7894 | 1.09117 | 819 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 1449.49 | L_Abluft | 210 | 3.7894 | 2.27234 | 854 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 1378.42 | L_Zuluft | 210 | 3.7894 | 2.16093 | 821 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 1731.63 | L_Abluft | 210 | 3.7894 | 2.71466 | 856 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 798.109 | L_Abluft | 220 | 3.03942 | 0.705435 | 696 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 836.791 | L_Abluft | 220 | 3.03942 | 0.739625 | 698 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 160 | 1298.11 | L_Zuluft | 220 | 3.03942 | 1.14738 | 641 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 160 | 836.791 | L_Zuluft | 220 | 3.03942 | 0.739625 | 643 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 140 | 1042.53 | L_Abluft | 200 | 3.60896 | 1.49382 | 733 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 140 | 1608.36 | L_Zuluft | 200 | 3.60896 | 2.30457 | 684 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 302.54 | L_Abluft | 130 | 2.9426 | 0.343834 | 800 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 718.173 | L_Abluft | 60 | 2.12207 | 0.59846 | 539 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 140 | 85 | L_Zuluft | 190 | 3.42851 | 0.110826 | 441 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 100 | 223.669 | L_Abluft | 80 | 2.82942 | 0.313933 | 512 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 100 | 141.625 | L_Abluft | 60 | 2.12207 | 0.118017 | 480 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 100 | 499.159 | L_Abluft | 60 | 2.12207 | 0.415953 | 483 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 100 | 358 | L_Abluft | 60 | 2.12207 | 0.298325 | 487 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 125 | 1152.82 | L_Zuluft | 130 | 2.9426 | 1.31018 | 759 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 125 | 248.993 | L_Zuluft | 130 | 2.9426 | 0.282979 | 761 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 759.164 | L_Zuluft | 130 | 2.9426 | 0.862785 | 859 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 140 | 262.5 | L_Abluft | 190 | 3.42851 | 0.342256 | 543 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 140 | 107.765 | L_Abluft | 190 | 3.42851 | 0.140507 | 545 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 1358.15 | L_Abluft | 435 | 3.84624 | 1.40117 | 813 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 1051.79 | L_Abluft | 435 | 3.84624 | 1.0851 | 815 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 114.253 | L_Abluft | 435 | 3.84624 | 0.117872 | 817 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 635.021 | L_Abluft | 435 | 3.84624 | 0.655133 | 835 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 1819.7 | L_Abluft | 435 | 3.84624 | 1.87734 | 837 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 5625.69 | L_Zuluft | 375 | 5.18082 | 13.3289 | 336 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 160 | 5625.69 | L_Zuluft | 375 | 5.18082 | 13.3289 | 347 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 120 | 160 | 5625.69 | L_Zuluft | 325 | 4.49005 | 10.2126 | 313 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 122 | 160 | 2085.75 | L_Zuluft | 325 | 4.49005 | 3.78638 | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 122 | 160 | 2973.3 | L_Zuluft | 325 | 4.49005 | 5.39761 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 122 | 160 | 951.267 | L_Zuluft | 325 | 4.49005 | 1.72689 | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 124 | 160 | 3744.45 | L_Zuluft | 325 | 4.49005 | 6.7975 | 279 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 124 | 160 | 620.137 | L_Zuluft | 325 | 4.49005 | 1.12577 | 277 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 124 | 160 | 1216.47 | L_Zuluft | 325 | 4.49005 | 2.20833 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 126 | 160 | 3758.52 | L_Zuluft | 325 | 4.49005 | 6.82305 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 126 | 160 | 620.137 | L_Zuluft | 325 | 4.49005 | 1.12577 | 259 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 126 | 160 | 1202.41 | L_Zuluft | 325 | 4.49005 | 2.1828 | 257 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 128 | 160 | 3917.76 | L_Zuluft | 325 | 4.49005 | 7.11214 | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 128 | 160 | 620.137 | L_Zuluft | 325 | 4.49005 | 1.12577 | 244 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 128 | 160 | 1043.16 | L_Zuluft | 325 | 4.49005 | 1.89371 | 242 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 130 | 160 | 5625.7 | L_Zuluft | 325 | 4.49005 | 10.2127 | 228 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 132 | 160 | 5625.69 | L_Zuluft | 325 | 4.49005 | 10.2126 | 213 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 135 | 160 | 5625.69 | L_Zuluft | 325 | 4.49005 | 10.2126 | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 137 | 160 | 5625.69 | L_Zuluft | 325 | 4.49005 | 10.2126 | 164 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 139 | 160 | 5625.7 | L_Zuluft | 325 | 4.49005 | 10.2127 | 146 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 141 | 160 | 5625.7 | L_Zuluft | 325 | 4.49005 | 10.2127 | 132 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 105 | 160 | 4590.66 | L_Zuluft | 300 | 4.14466 | 7.18432 | 325 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 103 | 160 | 4590.66 | L_Zuluft | 300 | 4.14466 | 7.18432 | 340 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 101 | 160 | 4590.66 | L_Zuluft | 300 | 4.14466 | 7.18432 | 354 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 99 | 160 | 4590.66 | L_Zuluft | 300 | 4.14466 | 7.18432 | 371 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 97 | 160 | 4590.66 | L_Zuluft | 300 | 4.14466 | 7.18432 | 385 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 95 | 160 | 4590.65 | L_Zuluft | 300 | 4.14466 | 7.1843 | 400 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 93 | 160 | 4590.66 | L_Zuluft | 300 | 4.14466 | 7.18432 | 415 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 58 | 160 | 4590.66 | L_Zuluft | 325 | 4.49005 | 8.33368 | 128 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 60 | 160 | 4590.66 | L_Zuluft | 325 | 4.49005 | 8.33368 | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 62 | 160 | 4590.65 | L_Zuluft | 325 | 4.49005 | 8.33366 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 64 | 160 | 4590.65 | L_Zuluft | 325 | 4.49005 | 8.33366 | 84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 66 | 160 | 4590.66 | L_Zuluft | 325 | 4.49005 | 8.33368 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 68 | 160 | 4590.65 | L_Zuluft | 325 | 4.49005 | 8.33366 | 51 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 160 | 4590.66 | L_Zuluft | 325 | 4.49005 | 8.33368 | 28 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 2707.5 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 674.999 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 1010 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 1040 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
8 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 2967.5 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 2857.5 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 727.499 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 687.501 | L_Umluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 200 | 315.508 | L_Abluft | 450 | 3.97887 | 0.346574 | 629 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 200 | 1000 | L_Abluft | 450 | 3.97887 | 1.09846 | 622 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 200 | 5215.3 | L_Abluft | 450 | 3.97887 | 5.7288 | 623 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 200 | 1036.5 | L_Zuluft | 450 | 3.97887 | 1.13855 | 189 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 125 | 1335.99 | L_Zuluft | 160 | 3.62166 | 2.22196 | 400 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 125 | 382.641 | L_Abluft | 160 | 3.62166 | 0.636392 | 400 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 125 | 144.857 | L_Abluft | 160 | 3.62166 | 0.24092 | 397 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 125 | 833.196 | L_Abluft | 160 | 3.62166 | 1.38574 | 395 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 125 | 245 | L_Abluft | 160 | 3.62166 | 0.407474 | 393 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 630 | 1217.14 | L_Abluft | 4000 | 3.5644 | 0.265845 | 12 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 450 | 347.694 | L_Abluft | 4000 | 6.98623 | 0.403474 | 16 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 4710.22 | L_Abluft | 100 | 3.53678 | 9.94245 | 231 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 5429.04 | L_Zuluft | 100 | 3.53678 | 11.4598 | 162 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 693.287 | L_Abluft | 250 | 3.45388 | 0.774926 | 213 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 386.037 | L_Zuluft | 250 | 3.45388 | 0.431496 | 222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 160 | 836.321 | L_Abluft | 250 | 3.45388 | 0.934803 | 278 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 1557.51 | L_Abluft | 250 | 3.45388 | 1.74091 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 2956.41 | L_Abluft | 250 | 3.45388 | 3.30455 | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 920.711 | L_Zuluft | 250 | 3.45388 | 1.02913 | 244 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 628.341 | L_Zuluft | 250 | 3.45388 | 0.702332 | 242 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 407.345 | L_Zuluft | 250 | 3.45388 | 0.455313 | 236 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 160 | 448.487 | L_Zuluft | 250 | 3.45388 | 0.501299 | 234 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 160 | 692.013 | L_Zuluft | 240 | 3.31573 | 0.717558 | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 160 | 1492.57 | L_Zuluft | 240 | 3.31573 | 1.54767 | 213 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 160 | 541.12 | L_Zuluft | 240 | 3.31573 | 0.561095 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 95 | L_Zuluft | 100 | 3.53678 | 0.200529 | 160 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 395.801 | L_Zuluft | 245 | 3.38481 | 0.426268 | 36 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 195.801 | L_Zuluft | 245 | 3.38481 | 0.210873 | 81 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 195.801 | L_Zuluft | 245 | 3.38481 | 0.210873 | 94 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 160.961 | L_Zuluft | 245 | 3.38481 | 0.173351 | 114 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 160 | 666.719 | L_Zuluft | 245 | 3.38481 | 0.718039 | 140 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 160 | 305.858 | L_Zuluft | 245 | 3.38481 | 0.329401 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 160 | 2587.42 | L_Zuluft | 245 | 3.38481 | 2.78659 | 67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 160 | 175.819 | L_Zuluft | 250 | 3.45388 | 0.196523 | 220 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 160 | 290.018 | L_Abluft | 250 | 3.45388 | 0.32417 | 276 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 210 | L_Abluft | 250 | 3.45388 | 0.234729 | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 100 | 120 | L_Abluft | 100 | 3.53678 | 0.253299 | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 160 | 3493.86 | L_Abluft | 240 | 3.31573 | 3.62283 | 262 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 345.801 | L_Abluft | 245 | 3.38481 | 0.372419 | 82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 305.858 | L_Abluft | 245 | 3.38481 | 0.329401 | 115 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 2887.42 | L_Abluft | 245 | 3.38481 | 3.10968 | 117 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 160 | 195.801 | L_Abluft | 245 | 3.38481 | 0.210873 | 131 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 195.801 | L_Abluft | 245 | 3.38481 | 0.210873 | 147 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 195.801 | L_Abluft | 245 | 3.38481 | 0.210873 | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 100 | 250.055 | L_Abluft | 60 | 2.12207 | 0.208373 | 255 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 160 | 1232.28 | L_Abluft | 280 | 3.86835 | 1.69747 | 240 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 160 | 1129.72 | L_Abluft | 280 | 3.86835 | 1.55621 | 244 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 2142.94 | L_Zuluft | 220 | 3.03942 | 1.89411 | 283 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 160 | 1944.1 | L_Zuluft | 220 | 3.03942 | 1.71835 | 287 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 100 | 438 | L_Zuluft | 60 | 2.12207 | 0.364989 | 338 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 100 | 395.232 | L_Zuluft | 60 | 2.12207 | 0.329351 | 331 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 125 | 551.803 | L_Zuluft | 110 | 2.48989 | 0.462571 | 251 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 250.521 | L_Zuluft | 60 | 2.12207 | 0.208761 | 342 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 1036.71 | L_Zuluft | 60 | 2.12207 | 0.863902 | 344 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 100 | 1022.2 | L_Abluft | 60 | 2.12207 | 0.851811 | 326 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 100 | 312.246 | L_Abluft | 60 | 2.12207 | 0.260198 | 335 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 107.204 | L_Abluft | 60 | 2.12207 | 0.0893338 | 309 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 125 | 370.05 | L_Zuluft | 140 | 3.16895 | 0.481628 | 186 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 73 | 125 | 370.05 | L_Abluft | 140 | 3.16895 | 0.481628 | 327 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 335.05 | L_Zuluft | 250 | 3.45388 | 0.374504 | 200 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 74 | 160 | 335.05 | L_Abluft | 250 | 3.45388 | 0.374504 | 312 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 84 | 160 | 235.05 | L_Zuluft | 270 | 3.73019 | 0.302759 | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 75 | 160 | 235.05 | L_Abluft | 270 | 3.73019 | 0.302759 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 85 | 180 | 415.05 | L_Zuluft | 300 | 3.27479 | 0.363004 | 155 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 76 | 180 | 415.05 | L_Abluft | 300 | 3.27479 | 0.363004 | 281 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 77 | 140 | 255.05 | L_Abluft | 200 | 3.60896 | 0.365454 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 86 | 140 | 255.05 | L_Zuluft | 200 | 3.60896 | 0.365454 | 135 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 78 | 140 | 255.05 | L_Abluft | 170 | 3.06761 | 0.271154 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 140 | 255.05 | L_Zuluft | 170 | 3.06761 | 0.271154 | 122 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 140 | 255.05 | L_Abluft | 180 | 3.24806 | 0.301107 | 230 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 140 | 255.05 | L_Zuluft | 180 | 3.24806 | 0.301107 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 125 | 270.05 | L_Abluft | 120 | 2.71624 | 0.265203 | 216 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
