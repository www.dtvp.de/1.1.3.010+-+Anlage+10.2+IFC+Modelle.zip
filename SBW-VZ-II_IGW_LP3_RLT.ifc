Properties of the parts of a building model (IFC2X3), part 16 of 18

# IfcFlowSegment: Wickelfalzrohr (1462)
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Wickelfalzrohr | EG_Verwaltung_FFB | 89 | 125 | 270.05 | L_Zuluft | 120 | 2.71624 | 0.265203 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 130.05 | L_Zuluft | 160 | 3.62166 | 0.216294 | 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 125 | 130.05 | L_Abluft | 160 | 3.62166 | 0.216294 | 199 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 135.05 | L_Abluft | 235 | 3.24665 | 0.134722 | 185 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 160 | 135.05 | L_Zuluft | 235 | 3.24665 | 0.134722 | 56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 135.05 | L_Zuluft | 235 | 3.24665 | 0.134722 | 43 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 160 | 135.05 | L_Abluft | 235 | 3.24665 | 0.134722 | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 160 | 435.05 | L_Zuluft | 235 | 3.24665 | 0.433994 | 265 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 93 | 160 | 435.05 | L_Abluft | 235 | 3.24665 | 0.433994 | 68 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 69 | 160 | 435.05 | L_Zuluft | 235 | 3.24665 | 0.433994 | 276 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 435.05 | L_Abluft | 235 | 3.24665 | 0.433994 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 62 | 180 | 1170.86 | L_Zuluft | 340 | 3.71143 | 1.28961 | 289 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 62 | 180 | 263.318 | L_Zuluft | 340 | 3.71143 | 0.290023 | 287 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 85 | 180 | 1394.51 | L_Abluft | 340 | 3.71143 | 1.53594 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 85 | 180 | 250.428 | L_Abluft | 340 | 3.71143 | 0.275826 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 2595.71 | L_Abluft | 190 | 3.42851 | 3.38436 | 453 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 2705.71 | L_Zuluft | 190 | 3.42851 | 3.52778 | 472 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 695 | L_Abluft | 190 | 3.42851 | 0.906163 | 460 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 106.943 | L_Abluft | 190 | 3.42851 | 0.139435 | 462 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 795 | L_Zuluft | 190 | 3.42851 | 1.03655 | 479 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 346.79 | L_Zuluft | 190 | 3.42851 | 0.452156 | 481 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 673.269 | L_Zuluft | 130 | 2.9426 | 0.765166 | 861 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 180 | 2035.2 | L_Zuluft | 240 | 2.61983 | 1.18276 | 842 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 356.883 | L_Zuluft | 110 | 1.98493 | 0.171959 | 846 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 155.778 | L_Zuluft | 110 | 1.98493 | 0.0750595 | 848 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 455.427 | L_Abluft | 210 | 3.7894 | 0.713968 | 848 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 465.427 | L_Abluft | 180 | 3.24806 | 0.549475 | 883 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 928.87 | L_Abluft | 130 | 2.9426 | 1.05565 | 903 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 552.095 | L_Abluft | 130 | 2.9426 | 0.627452 | 901 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 2502.16 | L_Abluft | 130 | 2.9426 | 2.84369 | 905 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 559.237 | L_Abluft | 60 | 2.12207 | 0.466017 | 601 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 80.2786 | L_Abluft | 60 | 2.12207 | 0.0668969 | 605 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 299.237 | L_Zuluft | 60 | 2.12207 | 0.249357 | 549 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 80.2786 | L_Zuluft | 60 | 2.12207 | 0.0668969 | 553 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 125 | 139.906 | L_Abluft | 145 | 3.28213 | 0.194189 | 587 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 1753.61 | L_Abluft | 60 | 2.12207 | 1.4613 | 599 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 180 | 1158.87 | L_Zuluft | 355 | 3.87517 | 1.38237 | 472 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 160 | 2904.13 | L_Zuluft | 240 | 3.31573 | 3.01133 | 487 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 125 | 139.147 | L_Zuluft | 115 | 2.60307 | 0.126464 | 480 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 505.401 | L_Zuluft | 60 | 2.12207 | 0.421155 | 489 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 988.931 | L_Zuluft | 60 | 2.12207 | 0.824085 | 491 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 93.8139 | L_Zuluft | 60 | 2.12207 | 0.078176 | 497 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 503 | L_Zuluft | 60 | 2.12207 | 0.419154 | 504 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 678.697 | L_Zuluft | 60 | 2.12207 | 0.565564 | 502 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 1145.4 | L_Abluft | 60 | 2.12207 | 0.954474 | 529 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 93.8139 | L_Abluft | 60 | 2.12207 | 0.078176 | 535 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 891.303 | L_Abluft | 60 | 2.12207 | 0.742731 | 537 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 503 | L_Abluft | 60 | 2.12207 | 0.419154 | 541 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 200 | 345 | L_Zuluft | 530 | 4.68623 | 0.513473 | 178 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 315 | 300 | L_Zuluft | 530 | 1.88913 | 0.047852 | 180 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 200 | 186.199 | L_Zuluft | 530 | 4.68623 | 0.277126 | 176 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 200 | 585.165 | L_Zuluft | 530 | 4.68623 | 0.870918 | 174 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 200 | 1742.5 | L_Zuluft | 530 | 4.68623 | 2.59341 | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 125 | 195 | L_Zuluft | 160 | 3.62166 | 0.324316 | 396 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 140 | 117.532 | L_Zuluft | 210 | 3.7894 | 0.184254 | 214 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 140 | 371.14 | L_Zuluft | 210 | 3.7894 | 0.581831 | 212 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 200 | 91.1397 | L_Zuluft | 430 | 3.80203 | 0.0920377 | 230 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 6000 | L_Zuluft | 120 | 2.71624 | 5.89232 | 357 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 1392.45 | L_Zuluft | 120 | 2.71624 | 1.36746 | 358 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 361.14 | L_Zuluft | 210 | 3.7894 | 0.566155 | 346 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 228.374 | L_Zuluft | 210 | 3.7894 | 0.358019 | 348 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 5727.63 | L_Abluft | 120 | 2.71624 | 5.62484 | 338 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 2321.39 | L_Abluft | 120 | 2.71624 | 2.27973 | 342 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 337.293 | L_Abluft | 120 | 2.71624 | 0.33124 | 344 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 1933.04 | L_Zuluft | 120 | 2.71624 | 1.89834 | 362 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 95 | L_Zuluft | 120 | 2.71624 | 0.093295 | 360 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 337.293 | L_Zuluft | 120 | 2.71624 | 0.33124 | 364 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 3702.11 | L_Zuluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 3928.77 | L_Zuluft |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 200 | 325.312 | L_Abluft | 450 | 3.97887 | 0.357342 | 625 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 7 | 200 | 939.101 | L_Abluft | 450 | 3.97887 | 1.03157 | 627 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 100 | 400.487 | L_Abluft | 90 | 3.1831 | 0.696914 | 87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 100 | 182.513 | L_Abluft | 90 | 3.1831 | 0.317603 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 100 | 305 | L_Abluft | 90 | 3.1831 | 0.530751 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 100 | 112.748 | L_Abluft | 90 | 3.1831 | 0.1962 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 100 | 112.748 | L_Zuluft | 90 | 3.1831 | 0.1962 | 153 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 100 | 400.487 | L_Zuluft | 90 | 3.1831 | 0.696914 | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 100 | 182.513 | L_Zuluft | 90 | 3.1831 | 0.317603 | 161 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 125 | 3223.09 | L_Abluft | 140 | 3.16895 | 4.19492 | 104 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 125 | 375.487 | L_Abluft | 140 | 3.16895 | 0.488704 | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 125 | 583.012 | L_Abluft | 140 | 3.16895 | 0.758802 | 108 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 125 | 2930.43 | L_Zuluft | 140 | 3.16895 | 3.81402 | 166 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 125 | 375.487 | L_Zuluft | 140 | 3.16895 | 0.488704 | 168 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 125 | 373.012 | L_Zuluft | 140 | 3.16895 | 0.485482 | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 160 | 3461.46 | L_Abluft | 230 | 3.17757 | 3.31938 | 83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 6000 | L_Zuluft | 230 | 3.17757 | 5.75372 | 144 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 160 | 1368.38 | L_Zuluft | 230 | 3.17757 | 1.31221 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 291.69 | L_Abluft | 220 | 3.03942 | 0.25782 | 132 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 2959.62 | L_Abluft | 220 | 3.03942 | 2.61596 | 134 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 291.7 | L_Zuluft | 220 | 3.03942 | 0.257829 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 3276.1 | L_Zuluft | 220 | 3.03942 | 2.89569 | 97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 160 | 215.487 | L_Zuluft | 275 | 3.79927 | 0.287121 | 112 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 160 | 215.487 | L_Abluft | 275 | 3.79927 | 0.287121 | 57 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 160 | 215.487 | L_Zuluft | 275 | 3.79927 | 0.287121 | 132 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 215.487 | L_Abluft | 275 | 3.79927 | 0.287121 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 1256.12 | L_Abluft | 220 | 3.03942 | 1.11026 | 120 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 160 | 5327.31 | L_Zuluft | 220 | 3.03942 | 4.70872 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 180 | 70 | L_Abluft | 320 | 3.49311 | 0.0689436 | 152 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 180 | 70 | L_Zuluft | 320 | 3.49311 | 0.0689436 | 189 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 334.993 | L_Zuluft | 160 | 3.62166 | 0.557146 | 196 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 203.196 | L_Zuluft | 160 | 3.62166 | 0.337947 | 198 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 125 | 334.993 | L_Abluft | 160 | 3.62166 | 0.557146 | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 125 | 509.791 | L_Abluft | 160 | 3.62166 | 0.847863 | 161 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 125 | 344.993 | L_Abluft | 160 | 3.62166 | 0.573778 | 178 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 125 | 344.993 | L_Zuluft | 160 | 3.62166 | 0.573778 | 215 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 259.874 | L_Abluft | 245 | 3.38481 | 0.279877 | 175 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 395.991 | L_Abluft | 245 | 3.38481 | 0.426473 | 177 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 259.874 | L_Abluft | 245 | 3.38481 | 0.279877 | 179 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 160 | 748.511 | L_Zuluft | 245 | 3.38481 | 0.806128 | 138 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 160 | 633.283 | L_Zuluft | 245 | 3.38481 | 0.68203 | 127 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 194.817 | L_Abluft | 245 | 3.38481 | 0.209813 | 181 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 160 | 376.717 | L_Abluft | 245 | 3.38481 | 0.405715 | 183 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 160 | 5728.18 | L_Zuluft | 245 | 3.38481 | 6.1691 | 129 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 160 | 107.997 | L_Zuluft | 245 | 3.38481 | 0.11631 | 133 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 180 | 424.781 | L_Zuluft | 330 | 3.60227 | 0.442787 | 342 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 180 | 1507.55 | L_Zuluft | 330 | 3.60227 | 1.57145 | 344 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 512.009 | L_Abluft | 120 | 2.71624 | 0.50282 | 335 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 4090.64 | L_Abluft | 120 | 2.71624 | 4.01723 | 337 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 234.702 | L_Abluft | 70 | 2.47574 | 0.258442 | 123 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 392.829 | L_Abluft | 70 | 2.47574 | 0.432564 | 125 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 757.055 | L_Abluft | 70 | 2.47574 | 0.833633 | 130 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 833.279 | L_Abluft | 70 | 2.47574 | 0.917567 | 127 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 6000 | L_Zuluft | 190 | 3.42851 | 7.82299 | 477 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 1933.65 | L_Zuluft | 190 | 3.42851 | 2.52115 | 476 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 220 | L_Zuluft | 190 | 3.42851 | 0.286843 | 474 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 1000 | L_Abluft | 190 | 3.42851 | 1.30383 | 458 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 5118.72 | L_Abluft | 190 | 3.42851 | 6.67394 | 457 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 220 | L_Abluft | 190 | 3.42851 | 0.286843 | 455 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 200 | 595.902 | L_Abluft | 430 | 3.80203 | 0.601773 | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 200 | 1028 | L_Zuluft | 430 | 3.80203 | 1.03813 | 238 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 200 | 329.289 | L_Zuluft | 430 | 3.80203 | 0.332534 | 234 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 378.777 | L_Abluft | 40 | 1.41471 | 0.152716 | 233 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 119.532 | L_Abluft | 40 | 1.41471 | 0.0481931 | 244 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 94.9847 | L_Zuluft | 40 | 1.41471 | 0.0382961 | 252 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 78.2615 | L_Zuluft | 40 | 1.41471 | 0.0315536 | 254 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 119.532 | L_Zuluft | 40 | 1.41471 | 0.0481931 | 265 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 457.185 | L_Abluft | 40 | 1.41471 | 0.184329 | 237 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 297.602 | L_Zuluft | 40 | 1.41471 | 0.119988 | 259 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 955.529 | L_Abluft | 40 | 1.41471 | 0.385252 | 242 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 594.471 | L_Zuluft | 40 | 1.41471 | 0.23968 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 140 | 1075.89 | L_Zuluft | 210 | 3.7894 | 1.68665 | 241 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 140 | 73.4315 | L_Abluft | 210 | 3.7894 | 0.115118 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 140 | 714.618 | L_Abluft | 210 | 3.7894 | 1.1203 | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 100 | 116.285 | L_Zuluft | 60 | 2.12207 | 0.0969016 | 271 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 100 | 473.583 | L_Zuluft | 60 | 2.12207 | 0.394641 | 273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 100 | 118.597 | L_Zuluft | 60 | 2.12207 | 0.0988279 | 282 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 100 | 231.044 | L_Abluft | 60 | 2.12207 | 0.192531 | 284 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 100 | 118.597 | L_Abluft | 60 | 2.12207 | 0.0988279 | 291 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 218.667 | L_Zuluft | 40 | 1.41471 | 0.0881626 | 288 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 146.285 | L_Zuluft | 40 | 1.41471 | 0.0589796 | 304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 1030.8 | L_Zuluft | 40 | 1.41471 | 0.415602 | 306 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 100 | 118.597 | L_Zuluft | 40 | 1.41471 | 0.0478162 | 316 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 146.322 | L_Abluft | 40 | 1.41471 | 0.0589944 | 297 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 730.252 | L_Abluft | 40 | 1.41471 | 0.294425 | 299 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 44 | 100 | 118.597 | L_Abluft | 40 | 1.41471 | 0.0478162 | 310 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 141.322 | L_Abluft | 40 | 1.41471 | 0.0569785 | 314 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 100 | 377.842 | L_Abluft | 40 | 1.41471 | 0.152339 | 316 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 141.307 | L_Zuluft | 40 | 1.41471 | 0.0569723 | 320 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 100 | 77.3267 | L_Zuluft | 40 | 1.41471 | 0.0311767 | 322 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 200 | 245.05 | L_Zuluft | 440 | 3.89045 | 0.258212 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 72 | 200 | 245.05 | L_Abluft | 440 | 3.89045 | 0.258212 | 344 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 200 | 245.05 | L_Zuluft | 435 | 3.84624 | 0.252811 | 234 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 71 | 200 | 245.05 | L_Abluft | 435 | 3.84624 | 0.252811 | 361 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 200 | 220.05 | L_Abluft | 435 | 3.84624 | 0.227019 | 374 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 200 | 220.05 | L_Zuluft | 435 | 3.84624 | 0.227019 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 635.021 | L_Abluft | 435 | 3.84624 | 0.655133 | 825 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 100 | 974.246 | L_Abluft | 60 | 2.12207 | 0.811848 | 549 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 100 | 192.92 | L_Abluft | 60 | 2.12207 | 0.160762 | 551 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 100 | 200 | L_Abluft | 60 | 2.12207 | 0.166662 | 555 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 100 | 830 | L_Abluft | 60 | 2.12207 | 0.691646 | 557 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 100 | 105.277 | L_Abluft | 60 | 2.12207 | 0.0877284 | 561 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 100 | 1234.25 | L_Zuluft | 60 | 2.12207 | 1.02851 | 510 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 100 | 192.92 | L_Zuluft | 60 | 2.12207 | 0.160762 | 512 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 100 | 149.999 | L_Zuluft | 60 | 2.12207 | 0.124996 | 516 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 100 | 689.999 | L_Zuluft | 60 | 2.12207 | 0.574983 | 521 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 100 | 105.277 | L_Zuluft | 60 | 2.12207 | 0.0877284 | 523 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 125 | 630.05 | L_Zuluft | 140 | 3.16895 | 0.820024 | 572 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 125 | 680.05 | L_Abluft | 140 | 3.16895 | 0.8851 | 622 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 160 | 645.05 | L_Abluft | 220 | 3.03942 | 0.570149 | 636 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 595.05 | L_Zuluft | 220 | 3.03942 | 0.525954 | 584 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 108 | L_Abluft | 60 | 2.12207 | 0.0899974 | 583 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 108 | L_Zuluft | 60 | 2.12207 | 0.0899974 | 543 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 269.966 | L_Zuluft | 60 | 2.12207 | 0.224965 | 529 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 375.05 | L_Zuluft | 60 | 2.12207 | 0.312532 | 531 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 99.5488 | L_Zuluft | 60 | 2.12207 | 0.0829549 | 533 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 420.763 | L_Abluft | 60 | 2.12207 | 0.350626 | 569 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 197.268 | L_Abluft | 60 | 2.12207 | 0.164385 | 571 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 99.5488 | L_Abluft | 60 | 2.12207 | 0.0829549 | 573 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 375.05 | L_Abluft | 60 | 2.12207 | 0.312532 | 603 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 375.05 | L_Zuluft | 60 | 2.12207 | 0.312532 | 551 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 108 | L_Abluft | 60 | 2.12207 | 0.0899974 | 615 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 108 | L_Zuluft | 60 | 2.12207 | 0.0899974 | 565 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 755.05 | L_Zuluft | 110 | 3.89045 | 1.89917 | 617 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 100 | 755.05 | L_Abluft | 110 | 3.89045 | 1.89917 | 674 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 695.05 | L_Zuluft | 220 | 3.03942 | 0.614343 | 607 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 695.05 | L_Abluft | 220 | 3.03942 | 0.614343 | 657 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 395.014 | L_Abluft | 185 | 3.33828 | 0.490402 | 770 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 140 | 395.014 | L_Abluft | 185 | 3.33828 | 0.490402 | 746 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 125 | 780.05 | L_Abluft | 130 | 2.9426 | 0.886521 | 710 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 125 | 780.05 | L_Zuluft | 130 | 2.9426 | 0.886521 | 655 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 2 | 630 | 900.09 | L_Abluft | 5000 | 4.4555 | 0.297887 | 12 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 400 | 1595.5 | L_Abluft | 2175 | 4.80781 | 1.05925 | 26 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 3 | 630 | 1228.87 | L_Abluft | 4350 | 3.87629 | 0.313692 | 24 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 4 | 400 | 5939.15 | L_Abluft | 2175 | 4.80781 | 3.94301 | 36 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 4 | 400 | 1495 | L_Abluft | 2175 | 4.80781 | 0.992532 | 38 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 4 | 400 | 1100 | L_Abluft | 2175 | 4.80781 | 0.730289 | 42 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 4 | 400 | 1419.96 | L_Abluft | 2175 | 4.80781 | 0.942713 | 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 400 | 1100 | L_Abluft | 2175 | 4.80781 | 0.730289 | 30 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 5 | 400 | 1419.96 | L_Abluft | 2175 | 4.80781 | 0.942713 | 28 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 250 | 2039.48 | L_Abluft | 650 | 3.67825 | 1.46836 | 18 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 250 | 1569.96 | L_Abluft | 650 | 3.67825 | 1.13032 | 20 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 6 | 250 | 699.997 | L_Abluft | 650 | 3.67825 | 0.503976 | 22 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 160 | 949.218 | L_Abluft | 245 | 3.38481 | 1.02228 | 137 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 124.404 | L_Abluft | 435 | 3.84624 | 0.128344 | 444 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 150 | L_Abluft | 435 | 3.84624 | 0.154751 | 446 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 597.354 | L_Abluft | 435 | 3.84624 | 0.616273 | 442 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 160 | 5327.31 | L_Abluft | 220 | 3.03942 | 4.70872 | 128 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 100 | 312.246 | L_Abluft | 60 | 2.12207 | 0.260198 | 318 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 337.191 | L_Umluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 291.56 | L_Umluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 216.069 | L_Zuluft | 320 | 2.82942 | 0.126697
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 2077.43 | L_Zuluft | 320 | 2.82942 | 1.21814
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 854.7 | L_Zuluft | 320 | 2.82942 | 0.501172
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 319.237 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 220.979 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 3888.89 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 304.886 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 223.148 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 267.01 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 223.122 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 3250.64 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 142.066 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 151.014 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 185 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 470 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 481.023 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 105 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 4268.44 | L_Zuluft | 734 | 3.31122 | 2.19958
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 166.975 | L_Zuluft | 734 | 3.31122 | 0.0860442
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 2529.37 | L_Zuluft | 734 | 3.31122 | 1.30341
5 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 234.755 | L_Zuluft | 721 | 3.25257 | 0.117051
Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 304.609 | L_Zuluft | 721 | 4.08003 | 0.265729
Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 311.21 | L_Zuluft | 721 | 4.08003 | 0.271487
Wickelfalzrohr | EG_Verwaltung_FFB |  | 280 | 119.522 | L_Zuluft | 721 | 3.25257 | 0.0595951
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 112.591 | L_Abluft | 450 | 3.97887 | 0.123676
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 105.93 | L_Abluft | 450 | 3.97887 | 0.11636
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 325.196 | L_Abluft | 450 | 3.97887 | 0.357215
Wickelfalzrohr | EG_Verwaltung_FFB |  | 250 | 600.949 | L_Zuluft | 675 | 3.81972 | 0.463955
2 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 861.583 | L_Abluft | 450 | 3.97887 | 0.946415
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 864.583 | L_Abluft | 450 | 3.97887 | 0.94971
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 223.984 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 28.2427 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 316.153 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 28.2427 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 309.662 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 222.643 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 518.993 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 386.299 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 212.979 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 124.312 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 130.748 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 185.371 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 555.262 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 557.89 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 298.281 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 301.116 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 553.981 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 929.897 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 413.467 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 362.84 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 1494.22 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 251.688 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 631.086 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 292.81 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 506.328 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 444.56 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 444.56 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 844.616 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 157.668 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 1394.62 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 157.668 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 212.826 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 85.8392 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 180.262 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 66.419 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 689.65 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 200 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 200 | L_Zuluft
3 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 30.132 | L_Abluft
3 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 430.132 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 335.445 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 335.445 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 189.296 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 1792.68 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 1000 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 189.296 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 2605.73 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 212.213 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 172.443 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 149.035 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 74.1312 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 441.454 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 1557.16 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 132.738 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 222.813 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 1438.6 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 423.965 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 160 | 638.774 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 945.522 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 202.091 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 2271.63 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 658.604 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 3490.25 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 348.518 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 131.357 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 194.159 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 319.002 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 3814.84 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 3716.5 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 435.271 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 352.381 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 120.198 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 218.4 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 462.992 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 313.174 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 790.873 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 1190.87 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 197.5 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 4714.57 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 197.5 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 4364.57 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 95.7251 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 877.796 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 308.131 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 548.59 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 735.359 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 855.573 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 361.052 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 1405.09 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 2273.96 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 545.427 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 100 | 1193.78 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 212.607 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 180 | 1310.59 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 531.441 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 888.307 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 421.766 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 200 | 336.307 | L_Zuluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 85 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 122.706 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB |  | 140 | 254.929 | L_Abluft

# IfcFlowSegment: Überströmgitter (4)
In: EG_Verwaltung_FFB
Description: Überströmgitter
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Überströmgitter; Info: Nachströmung

# IfcFlowTerminal: Abluftventil (44)
Description: Abluftventil
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Connection diameter (mm): 100 mm; Geom-Head diameter (mm): 150 mm; Calc-Pressure loss (Pa): 30 Pa; Name: Abluftventil; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | In | Section No | Tech-Medium | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No. | Floor | Floor No.
Abluftventil | Wartung_FFB | 46 | L_Zuluft | 48.4154 | 100 | 151 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 51 | L_Abluft | 16.8905 | 100 | 183 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 52 | L_Abluft | 76.3709 | 100 | 152 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 47 | L_Zuluft | 88.3964 | 100 | 122 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 57 | L_Abluft | 89.983 | 100 | 72 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 52 | L_Zuluft | 86.0979 | 100 | 40 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 56 | L_Abluft | 61.8229 | 100 | 99 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 51 | L_Zuluft | 57.1813 | 100 | 70 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 55 | L_Abluft | 0 | 100 | 123 | Wartung_FFB | 2
Abluftventil | Wartung_FFB | 50 | L_Zuluft | 0 | 100 | 92 | Wartung_FFB | 2
Abluftventil | EG_Verwaltung_FFB | 52 | L_Abluft | 28.3696 | 60 | 542 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 51 | L_Abluft | 22.6819 | 60 | 562 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 50 | L_Zuluft | 10.9294 | 60 | 505 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 49 | L_Zuluft | 5.6693 | 60 | 524 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 48 | L_Zuluft | 2.59319 | 60 | 544 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 50 | L_Abluft | 11.0427 | 60 | 584 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 48 | L_Abluft | 0 | 60 | 616 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 47 | L_Zuluft | 0 | 60 | 566 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 55 | L_Abluft | 46.5018 | 60 | 488 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 53 | L_Abluft | 34.5987 | 80 | 521 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 52 | L_Zuluft | 24.8574 | 80 | 468 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 87 | L_Abluft | 75.6142 | 40 | 166 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 63 | L_Zuluft | 67.5537 | 40 | 354 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 90 | L_Abluft | 45.0531 | 70 | 135 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 67 | L_Zuluft | 39.8335 | 70 | 331 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 68 | L_Zuluft | 24.0864 | 90 | 312 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 91 | L_Abluft | 26.941 | 90 | 118 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 38 | L_Zuluft | 108.613 | 40 | 266 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 46 | L_Abluft | 87.2823 | 40 | 278 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 36 | L_Zuluft | 104.877 | 40 | 299 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 45 | L_Abluft | 82.4276 | 60 | 292 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 37 | L_Zuluft | 101.181 | 60 | 283 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 15 | L_Abluft | 11.8142 | 60 | 256 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 11 | L_Zuluft | 19.3182 | 60 | 339 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 10 | L_Zuluft | 16.1379 | 60 | 354 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 9 | L_Abluft | 11.13 | 60 | 336 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 10 | L_Abluft | 12.102 | 60 | 319 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 25 | L_Zuluft | 5.75224 | 90 | 162 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 27 | L_Abluft | 13.7136 | 90 | 100 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 43 | L_Abluft | 88.767 | 40 | 328 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 34 | L_Zuluft | 101.766 | 40 | 333 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 44 | L_Abluft | 82.0734 | 40 | 311 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 35 | L_Zuluft | 102.096 | 40 | 317 | EG_Verwaltung_FFB | 0
Abluftventil | EG_Verwaltung_FFB | 48 | L_Abluft | 92.9621 | 40 | 245 | EG_Verwaltung_FFB | 0

# IfcFlowTerminal: Bodengitter
In: EG_Verwaltung_FFB
Description: Bodengitter
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Section No: 2; Geom-Side 1 (mm): 600 mm; Geom-Side 2 (mm): 600 mm; Geom-Length (mm): 1 mm; Tech-Medium: L_Abluft; Calc-Pressure loss (Pa): 100 Pa; Calc-Required throttling (Pa): 0 Pa; Calc-Volumetric flow (m3/h): 4000 m3/hour; Name: Bodengitter; Pos. No.: 19; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Bodengitter rund (6)
In: EG_Verwaltung_FFB
Description: Bodengitter rund
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Bodengitter rund; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Geom-Connection diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No.
Bodengitter rund | 1 | 315 | 200 | L_Fortluft | 25 | 0 | 530 | 9
Bodengitter rund | 2 | 315 | 200 | L_Abluft | 25 | 0 | 530 | 15
Bodengitter rund | 45 | 315 | 200 | L_Zuluft | 25 | 11.6189 | 530 | 181
Bodengitter rund | 6 | 250 | 200 | L_Abluft | 50 | 30.5832 | 650 | 23
Bodengitter rund | 5 | 400 | 300 | L_Abluft | 50 | 0 | 2175 | 31
Bodengitter rund | 4 | 400 | 300 | L_Abluft | 50 | 9.24477 | 2175 | 43

# IfcFlowTerminal: DTQ0 - 325 - 325 - K1 - 160 (67)
In: EG_Verwaltung_FFB
Description: DTQ0 - 325 - 325 - K1 - 160
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Connection diameter (mm): 160 mm; Geom-Panel size 1 (mm): 323 mm; Geom-Panel size 2 (mm): 323 mm; Calc-Pressure loss (Pa): 15 Pa; Name: DTQ0 - 325 - 325 - K1 - 160; Info: Linear-Luftdurchlass; Info 1: Wildeboer; Info 2: innerhalb von 72 Stunden lieferbar (Express-Service); Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Tech-Medium | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No.
DTQ0 - 325 - 325 - K1 - 160 | 38 | L_Zuluft | 11.1598 | 110 | 629
DTQ0 - 325 - 325 - K1 - 160 | 40 | L_Abluft | 28.2499 | 110 | 684
DTQ0 - 325 - 325 - K1 - 160 | 43 | L_Abluft | 46.0005 | 140 | 634
DTQ0 - 325 - 325 - K1 - 160 | 42 | L_Zuluft | 32.5841 | 140 | 582
DTQ0 - 325 - 325 - K1 - 160 | 53 | L_Zuluft | 43.6763 | 120 | 448
DTQ0 - 325 - 325 - K1 - 160 | 56 | L_Abluft | 57.6425 | 120 | 468
DTQ0 - 325 - 325 - K1 - 160 | 36 | L_Zuluft | 32.2221 | 130 | 667
DTQ0 - 325 - 325 - K1 - 160 | 38 | L_Abluft | 46.0963 | 130 | 719
DTQ0 - 325 - 325 - K1 - 160 | 32 | L_Zuluft | 25.5568 | 110 | 735
DTQ0 - 325 - 325 - K1 - 160 | 33 | L_Abluft | 31.4296 | 110 | 789
DTQ0 - 325 - 325 - K1 - 160 | 10 | L_Zuluft | 44.5537 | 130 | 871
DTQ0 - 325 - 325 - K1 - 160 | 10 | L_Abluft | 40.8571 | 130 | 913
DTQ0 - 325 - 325 - K1 - 160 | 12 | L_Zuluft | 22.6929 | 110 | 839
DTQ0 - 325 - 325 - K1 - 160 | 12 | L_Abluft | 28.9593 | 110 | 878
DTQ0 - 325 - 325 - K1 - 160 | 30 | L_Zuluft | 8.99567 | 130 | 767
DTQ0 - 325 - 325 - K1 - 160 | 32 | L_Abluft | 26.0189 | 130 | 805
DTQ0 - 325 - 325 - K1 - 160 | 92 | L_Abluft | 71.0227 | 235 | 91
DTQ0 - 325 - 325 - K1 - 160 | 83 | L_Abluft | 69.4289 | 235 | 183
DTQ0 - 325 - 325 - K1 - 160 | 69 | L_Zuluft | 64.466 | 235 | 285
DTQ0 - 325 - 325 - K1 - 160 | 92 | L_Zuluft | 57.0446 | 235 | 54
DTQ0 - 325 - 325 - K1 - 160 | 65 | L_Zuluft | 55.188 | 140 | 342
DTQ0 - 325 - 325 - K1 - 160 | 88 | L_Abluft | 66.2136 | 140 | 152
DTQ0 - 325 - 325 - K1 - 160 | 81 | L_Abluft | 61.5727 | 160 | 211
DTQ0 - 325 - 325 - K1 - 160 | 90 | L_Zuluft | 22.465 | 160 | 86
DTQ0 - 325 - 325 - K1 - 160 | 86 | L_Zuluft | 62.2246 | 200 | 147
DTQ0 - 325 - 325 - K1 - 160 | 77 | L_Abluft | 61.2165 | 200 | 273
DTQ0 - 325 - 325 - K1 - 160 | 88 | L_Zuluft | 72.8179 | 180 | 116
DTQ0 - 325 - 325 - K1 - 160 | 79 | L_Abluft | 70.5111 | 180 | 242
DTQ0 - 325 - 325 - K1 - 160 | 83 | L_Zuluft | 66.717 | 140 | 198
DTQ0 - 325 - 325 - K1 - 160 | 73 | L_Abluft | 62.3033 | 140 | 339
DTQ0 - 325 - 325 - K1 - 160 | 84 | L_Zuluft | 59.3927 | 270 | 178
DTQ0 - 325 - 325 - K1 - 160 | 75 | L_Abluft | 57.886 | 270 | 304
DTQ0 - 325 - 325 - K1 - 160 | 89 | L_Zuluft | 81.6325 | 120 | 102
DTQ0 - 325 - 325 - K1 - 160 | 80 | L_Abluft | 74.9393 | 120 | 228
DTQ0 - 325 - 325 - K1 - 160 | 87 | L_Zuluft | 74.3723 | 170 | 133
DTQ0 - 325 - 325 - K1 - 160 | 78 | L_Abluft | 69.3871 | 170 | 259
DTQ0 - 325 - 325 - K1 - 160 | 93 | L_Abluft | 72.3952 | 235 | 77
DTQ0 - 325 - 325 - K1 - 160 | 70 | L_Zuluft | 64.5855 | 235 | 274
DTQ0 - 325 - 325 - K1 - 160 | 82 | L_Abluft | 69.8502 | 235 | 196
DTQ0 - 325 - 325 - K1 - 160 | 91 | L_Zuluft | 56.8871 | 235 | 67
DTQ0 - 325 - 325 - K1 - 160 | 11 | L_Zuluft | 55.5154 | 110 | 854
DTQ0 - 325 - 325 - K1 - 160 | 33 | L_Zuluft | 45.9945 | 50 | 718
DTQ0 - 325 - 325 - K1 - 160 | 35 | L_Abluft | 157.301 | 50 | 760
DTQ0 - 325 - 325 - K1 - 160 | 49 | L_Abluft | 12.4894 | 85 | 596
DTQ0 - 325 - 325 - K1 - 160 | 51 | L_Zuluft | 30.9288 | 115 | 484
DTQ0 - 325 - 325 - K1 - 160 | 54 | L_Abluft | 54.8295 | 85 | 501
DTQ0 - 325 - 325 - K1 - 160 | 40 | L_Zuluft | 146.766 | 115 | 602
DTQ0 - 325 - 325 - K1 - 160 | 27 | L_Zuluft | 136.115 | 120 | 377
DTQ0 - 325 - 325 - K1 - 160 | 37 | L_Abluft | 120.431 | 120 | 360
DTQ0 - 325 - 325 - K1 - 160 |  | L_Zuluft | 152.001 | 130
DTQ0 - 325 - 325 - K1 - 160 | 12 | L_Zuluft | 162.204 | 130 | 591
DTQ0 - 325 - 325 - K1 - 160 | 14 | L_Zuluft | 56.5989 | 220 | 292
DTQ0 - 325 - 325 - K1 - 160 | 14 | L_Abluft | 3.92195 | 220 | 266
DTQ0 - 325 - 325 - K1 - 160 | 16 | L_Abluft | 59.9186 | 130 | 235
DTQ0 - 325 - 325 - K1 - 160 | 15 | L_Zuluft | 60.9799 | 130 | 277
DTQ0 - 325 - 325 - K1 - 160 | 17 | L_Abluft | 80.6367 | 110 | 221
DTQ0 - 325 - 325 - K1 - 160 | 16 | L_Zuluft | 74.0553 | 110 | 263
DTQ0 - 325 - 325 - K1 - 160 | 18 | L_Zuluft | 0 | 160 | 227
DTQ0 - 325 - 325 - K1 - 160 | 19 | L_Abluft | 0 | 160 | 190
DTQ0 - 325 - 325 - K1 - 160 | 20 | L_Abluft | 30.2605 | 160 | 169
DTQ0 - 325 - 325 - K1 - 160 | 19 | L_Zuluft | 30.3864 | 160 | 206
DTQ0 - 325 - 325 - K1 - 160 | 26 | L_Abluft | 44.316 | 140 | 118
DTQ0 - 325 - 325 - K1 - 160 | 24 | L_Zuluft | 36.4837 | 140 | 180
DTQ0 - 325 - 325 - K1 - 160 | 13 | L_Zuluft | 0 | 100 | 174
DTQ0 - 325 - 325 - K1 - 160 | 13 | L_Abluft | 0 | 100 | 243
DTQ0 - 325 - 325 - K1 - 160 | 22 | L_Zuluft | 151.017 | 160 | 406
DTQ0 - 325 - 325 - K1 - 160 | 31 | L_Zuluft | 142.857 | 160 | 405

# IfcFlowTerminal: DTQ0 - 400 - 400 - K1 - 200 (119)
In: EG_Verwaltung_FFB
Description: DTQ0 - 400 - 400 - K1 - 200
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Connection diameter (mm): 200 mm; Geom-Panel size 1 (mm): 398 mm; Geom-Panel size 2 (mm): 398 mm; Calc-Pressure loss (Pa): 15 Pa; Name: DTQ0 - 400 - 400 - K1 - 200; Info: Linear-Luftdurchlass; Info 1: Wildeboer; Info 2: innerhalb von 72 Stunden lieferbar (Express-Service); Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Section No | Tech-Medium | Calc-Required throttling (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No.
DTQ0 - 400 - 400 - K1 - 200 | 37 | L_Zuluft | 28.3884 | 220 | 649
DTQ0 - 400 - 400 - K1 - 200 | 39 | L_Abluft | 41.7813 | 220 | 704
DTQ0 - 400 - 400 - K1 - 200 | 55 | L_Zuluft | 59.5233 | 435 | 417
DTQ0 - 400 - 400 - K1 - 200 | 57 | L_Zuluft | 56.4697 | 435 | 407
DTQ0 - 400 - 400 - K1 - 200 | 58 | L_Zuluft | 59.1806 | 435 | 397
DTQ0 - 400 - 400 - K1 - 200 | 59 | L_Abluft | 50.4198 | 435 | 428
DTQ0 - 400 - 400 - K1 - 200 | 57 | L_Abluft | 54.2676 | 435 | 448
DTQ0 - 400 - 400 - K1 - 200 | 58 | L_Abluft | 52.5074 | 435 | 438
DTQ0 - 400 - 400 - K1 - 200 | 14 | L_Zuluft | 41.0609 | 435 | 799
DTQ0 - 400 - 400 - K1 - 200 | 16 | L_Abluft | 49.7125 | 435 | 821
DTQ0 - 400 - 400 - K1 - 200 | 15 | L_Zuluft | 36.5087 | 435 | 788
DTQ0 - 400 - 400 - K1 - 200 | 15 | L_Abluft | 50.3295 | 435 | 833
DTQ0 - 400 - 400 - K1 - 200 | 16 | L_Zuluft | 38.9863 | 435 | 777
DTQ0 - 400 - 400 - K1 - 200 | 14 | L_Abluft | 54.0797 | 435 | 841
DTQ0 - 400 - 400 - K1 - 200 | 42 | L_Abluft | 47.8211 | 220 | 651
DTQ0 - 400 - 400 - K1 - 200 | 41 | L_Abluft | 47.0176 | 220 | 672
DTQ0 - 400 - 400 - K1 - 200 | 41 | L_Zuluft | 40.6052 | 220 | 592
DTQ0 - 400 - 400 - K1 - 200 | 39 | L_Zuluft | 39.1012 | 220 | 615
DTQ0 - 400 - 400 - K1 - 200 | 37 | L_Abluft | 31.1501 | 200 | 736
DTQ0 - 400 - 400 - K1 - 200 | 35 | L_Zuluft | 6.16354 | 200 | 687
DTQ0 - 400 - 400 - K1 - 200 | 36 | L_Abluft | 30.6718 | 185 | 749
DTQ0 - 400 - 400 - K1 - 200 | 34 | L_Abluft | 25.9575 | 185 | 773
DTQ0 - 400 - 400 - K1 - 200 | 34 | L_Zuluft | 14.7013 | 185 | 704
DTQ0 - 400 - 400 - K1 - 200 | 31 | L_Zuluft | 5.01448 | 185 | 750
DTQ0 - 400 - 400 - K1 - 200 | 13 | L_Zuluft | 18.3387 | 210 | 824
DTQ0 - 400 - 400 - K1 - 200 | 13 | L_Abluft | 30.7541 | 210 | 859
DTQ0 - 400 - 400 - K1 - 200 | 11 | L_Abluft | 39.8128 | 180 | 898
DTQ0 - 400 - 400 - K1 - 200 | 85 | L_Zuluft | 53.4518 | 300 | 168
DTQ0 - 400 - 400 - K1 - 200 | 76 | L_Abluft | 66.0353 | 300 | 294
