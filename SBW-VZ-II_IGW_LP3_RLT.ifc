Properties of the parts of a building model (IFC2X3), part 7 of 18

# IfcFlowMovingDevice: Technik (ca. 4.300 m³/h) (2)
Name | Geom-Length (mm) (mm) | Geom-Height (mm) (mm)
Technik (ca. 4.300 m³/h) | 7498 | 950 | Pset_MEP - Info: ZUL+ABL: 1 x 7,5 x 1,6 m; Info 1: 2000 kg
Technik (ca. 4.300 m³/h) | 4897 | 808

# IfcFlowMovingDevice: Warmarbeitsplätze (ca. 2.700 m³/h) (2)
In: Wartung_FFB
Description: Warmarbeitsplätze (ca. 2.700 m³/h)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Width (mm): 689 mm; Name: Warmarbeitsplätze (ca. 2.700 m³/h); Floor: Wartung_FFB; Floor No.: 2; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Geom-Height (mm) (mm)
Warmarbeitsplätze (ca. 2.700 m³/h) | 4897 | 808
Warmarbeitsplätze (ca. 2.700 m³/h) | 7498 | 950 | Pset_MEP - Info: ZUL+ABL: 0,7 x 12 x 2,5 m; Info 1: 1500 kg

# IfcFlowSegment: Flexrohr (292)
In: EG_Verwaltung_FFB
Description: Flexrohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Flexrohr
Name | Section No | Geom-Main diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Flexrohr | 39 | 200 | 698.114 | L_Abluft | 220 | 1.94523 | 0.36983 | 703 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 37 | 200 | 706.933 | L_Zuluft | 220 | 1.94523 | 0.374263 | 648 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 40 | 160 | 562.14 | L_Abluft | 110 | 1.51971 | 0.242544 | 683 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 38 | 160 | 472.645 | L_Zuluft | 110 | 1.51971 | 0.20393 | 628 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 53 | 160 | 554.346 | L_Zuluft | 120 | 1.65786 | 0.28355 | 447 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 56 | 160 | 687.119 | L_Abluft | 120 | 1.65786 | 0.351464 | 467 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 37 | 200 | 437.383 | L_Abluft | 200 | 1.76839 | 0.18696 | 735 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 35 | 200 | 474.117 | L_Zuluft | 200 | 1.76839 | 0.202662 | 686 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 32 | 160 | 1013.19 | L_Zuluft | 110 | 1.51971 | 0.437157 | 734 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 33 | 160 | 884.291 | L_Abluft | 110 | 1.51971 | 0.381542 | 788 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 30 | 160 | 575.011 | L_Zuluft | 130 | 1.79602 | 0.344046 | 766 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 34 | 200 | 399.96 | L_Zuluft | 185 | 1.63576 | 0.146756 | 703 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 31 | 200 | 399.96 | L_Zuluft | 185 | 1.63576 | 0.146756 | 749 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 42 | 200 | 570.317 | L_Abluft | 220 | 1.94523 | 0.293896 | 650 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 41 | 200 | 965.78 | L_Zuluft | 220 | 1.94523 | 0.497687 | 591 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 41 | 200 | 570.326 | L_Abluft | 220 | 1.94523 | 0.293901 | 671 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 39 | 200 | 961.842 | L_Zuluft | 220 | 1.94523 | 0.495658 | 614 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 38 | 160 | 531.47 | L_Abluft | 130 | 1.79602 | 0.317994 | 718 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 43 | 160 | 527.677 | L_Abluft | 140 | 1.93417 | 0.365122 | 633 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 42 | 160 | 959.791 | L_Zuluft | 140 | 1.93417 | 0.66412 | 581 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 160 | 590.774 | L_Abluft | 110 | 1.51971 | 0.254899 | 877 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 10 | 160 | 561.187 | L_Abluft | 130 | 1.79602 | 0.335774 | 912 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 13 | 200 | 809.339 | L_Zuluft | 210 | 1.85681 | 0.380683 | 823 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 90 | 160 | 512.036 | L_Zuluft | 160 | 2.21049 | 0.460592 | 85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 88 | 160 | 547.768 | L_Abluft | 140 | 1.93417 | 0.431384 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 80 | 160 | 585.795 | L_Abluft | 120 | 1.65786 | 0.299636 | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 87 | 160 | 635.725 | L_Zuluft | 170 | 2.34864 | 0.644311 | 132 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 78 | 160 | 656.538 | L_Abluft | 170 | 2.34864 | 0.665405 | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 84 | 160 | 1099.55 | L_Zuluft | 270 | 3.73019 | 2.77806 | 177 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 75 | 160 | 1215.95 | L_Abluft | 270 | 3.73019 | 3.07213 | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 83 | 160 | 732.247 | L_Zuluft | 140 | 1.93417 | 0.506672 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 73 | 160 | 749.696 | L_Abluft | 140 | 1.93417 | 0.518746 | 338 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 76 | 200 | 933.387 | L_Abluft | 300 | 2.65258 | 0.789225 | 293 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 85 | 200 | 969.377 | L_Zuluft | 300 | 2.65258 | 0.812451 | 167 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 82 | 200 | 964.281 | L_Zuluft | 250 | 2.21049 | 0.63882 | 212 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 74 | 200 | 955.598 | L_Abluft | 250 | 2.21049 | 0.633067 | 324 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 81 | 200 | 1019.79 | L_Zuluft | 440 | 3.89045 | 2.06245 | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 79 | 200 | 998.941 | L_Zuluft | 435 | 3.84624 | 2.13572 | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 70 | 200 | 1267.43 | L_Abluft | 435 | 3.84624 | 2.50593 | 383 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 72 | 200 | 1011.51 | L_Abluft | 440 | 3.89045 | 2.04572 | 353 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 80 | 200 | 1289.45 | L_Zuluft | 435 | 3.84624 | 2.54948 | 243 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 71 | 200 | 1559.01 | L_Abluft | 435 | 3.84624 | 3.08244 | 369 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 86 | 160 | 783.573 | L_Zuluft | 200 | 2.76311 | 1.09399 | 146 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 77 | 160 | 832.898 | L_Abluft | 200 | 2.76311 | 1.16285 | 272 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 88 | 160 | 387.391 | L_Zuluft | 180 | 2.4868 | 0.541104 | 115 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 79 | 160 | 536.982 | L_Abluft | 180 | 2.4868 | 0.609081 | 241 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 89 | 160 | 559.337 | L_Zuluft | 120 | 1.65786 | 0.309042 | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 81 | 160 | 424.49 | L_Abluft | 160 | 2.21049 | 0.676758 | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 69 | 160 | 591 | L_Zuluft | 235 | 3.24665 | 1.13459 | 284 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 93 | 160 | 608.065 | L_Abluft | 235 | 3.24665 | 1.16735 | 76 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 58 | 200 | 1140.36 | L_Abluft | 435 | 3.84624 | 2.2547 | 437 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 55 | 200 | 712.069 | L_Zuluft | 435 | 3.84624 | 1.97338 | 416 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 57 | 200 | 1102.44 | L_Zuluft | 435 | 3.84624 | 2.17972 | 406 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 58 | 200 | 1120.3 | L_Zuluft | 435 | 3.84624 | 2.21502 | 396 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 33 | 160 | 693.718 | L_Zuluft | 50 | 0.690777 | 0.0650855 | 717 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 35 | 160 | 703.067 | L_Abluft | 50 | 0.690777 | 0.0659626 | 759 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 54 | 160 | 724.003 | L_Abluft | 85 | 1.17432 | 0.189017 | 500 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 49 | 160 | 912.694 | L_Abluft | 85 | 1.17432 | 0.310044 | 595 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 365.646 | L_Zuluft | 195 | 1.72418 | 0.241226 | 535 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 13 | 200 | 418.074 | L_Zuluft | 190 | 1.67997 | 0.231956 | 551 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 24 | 200 | 666.234 | L_Abluft | 195 | 1.72418 | 0.241144 | 536 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 23 | 200 | 655.421 | L_Abluft | 190 | 1.67997 | 0.253378 | 552 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 200 | 690.063 | L_Abluft | 195 | 1.72418 | 0.423692 | 567 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 25 | 200 | 454.052 | L_Abluft | 190 | 1.67997 | 0.175532 | 503 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 200 | 302.973 | L_Abluft | 190 | 1.67997 | 0.191104 | 484 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 15 | 200 | 454.052 | L_Zuluft | 190 | 1.67997 | 0.175532 | 505 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 20 | 200 | 454.052 | L_Zuluft | 190 | 1.67997 | 0.175532 | 450 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 29 | 200 | 484.592 | L_Abluft | 190 | 1.67997 | 0.187338 | 445 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 19 | 200 | 484.592 | L_Zuluft | 190 | 1.67997 | 0.187338 | 465 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 18 | 200 | 522.387 | L_Zuluft | 190 | 1.67997 | 0.201949 | 488 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 28 | 200 | 582.867 | L_Abluft | 190 | 1.67997 | 0.22533 | 469 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 30 | 200 | 800.389 | L_Abluft | 400 | 3.53678 | 1.34042 | 422 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 21 | 200 | 794.845 | L_Zuluft | 400 | 3.53678 | 1.33113 | 420 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 34 | 200 | 634.683 | L_Abluft | 210 | 1.85681 | 0.379419 | 367 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr |  | 160 | 587.743 | L_Zuluft | 130 | 1.79602 | 0.399415 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr |  | 200 | 574.456 | L_Zuluft | 170 | 1.50313 | 0.215936 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr |  | 200 | 542.428 | L_Zuluft | 170 | 1.50313 | 0.210168 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 41 | 200 | 657.184 | L_Zuluft | 450 | 3.97887 | 1.38961 | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 10 | 200 | 679.467 | L_Abluft | 170 | 1.50313 | 0.211319 | 619 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 200 | 593.83 | L_Abluft | 170 | 1.50313 | 0.214189 | 604 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 160 | 552.754 | L_Abluft | 130 | 1.79602 | 0.330729 | 590 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 27 | 160 | 542.661 | L_Zuluft | 120 | 1.65786 | 0.350504 | 376 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 37 | 160 | 561.151 | L_Abluft | 120 | 1.65786 | 0.225921 | 359 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 39 | 200 | 901.943 | L_Zuluft | 210 | 1.85681 | 0.424241 | 248 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 28 | 200 | 599.234 | L_Zuluft | 210 | 1.85681 | 0.281858 | 353 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 49 | 200 | 756.088 | L_Abluft | 210 | 1.85681 | 0.37201 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 40 | 200 | 641.956 | L_Zuluft | 210 | 1.85681 | 0.309481 | 219 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 16 | 200 | 721.609 | L_Abluft | 440 | 3.89045 | 1.45941 | 54 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 15 | 200 | 1270.19 | L_Abluft | 440 | 3.89045 | 2.56887 | 69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 662.261 | L_Abluft | 440 | 3.89045 | 1.33938 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 15 | 200 | 780.18 | L_Zuluft | 440 | 3.89045 | 1.57786 | 34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 16 | 200 | 870.575 | L_Zuluft | 440 | 3.89045 | 1.76068 | 22 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 721.609 | L_Zuluft | 440 | 3.89045 | 1.45941 | 48 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 13 | 200 | 464.148 | L_Zuluft | 440 | 3.89045 | 0.93871 | 62 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 200 | 527.55 | L_Zuluft | 440 | 3.89045 | 1.06694 | 77 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 9 | 200 | 527.55 | L_Zuluft | 440 | 3.89045 | 1.06694 | 115 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 10 | 200 | 551.963 | L_Zuluft | 440 | 3.89045 | 1.11631 | 103 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 200 | 722.639 | L_Zuluft | 440 | 3.89045 | 1.46149 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 13 | 200 | 783.574 | L_Abluft | 440 | 3.89045 | 1.58473 | 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 10 | 200 | 761.805 | L_Abluft | 440 | 3.89045 | 1.5407 | 141 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 9 | 200 | 556.955 | L_Abluft | 440 | 3.89045 | 1.12641 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 200 | 556.955 | L_Abluft | 440 | 3.89045 | 1.12641 | 109 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 200 | 953.951 | L_Abluft | 440 | 3.89045 | 1.9293 | 125 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 16 | 160 | 493.749 | L_Abluft | 130 | 1.79602 | 0.297203 | 234 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 15 | 160 | 516.002 | L_Zuluft | 130 | 1.79602 | 0.31044 | 276 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 16 | 160 | 403.698 | L_Zuluft | 110 | 1.51971 | 0.174182 | 262 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 19 | 160 | 473.066 | L_Zuluft | 160 | 2.21049 | 0.572266 | 205 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 20 | 160 | 607.477 | L_Abluft | 160 | 2.21049 | 0.546444 | 168 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 18 | 160 | 573.037 | L_Zuluft | 160 | 2.21049 | 0.668161 | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 19 | 160 | 760.058 | L_Abluft | 160 | 2.21049 | 0.683696 | 189 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 160 | 637.272 | L_Abluft | 220 | 3.03942 | 1.07392 | 265 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 160 | 933.861 | L_Zuluft | 220 | 3.03942 | 1.57373 | 291 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 8 | 200 | 1353.04 | L_Zuluft | 315 | 2.78521 | 1.41332 | 377 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 9 | 200 | 954.198 | L_Zuluft | 315 | 2.78521 | 0.996711 | 369 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 7 | 200 | 957.705 | L_Abluft | 315 | 2.78521 | 1.00037 | 359 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 8 | 200 | 1332.41 | L_Abluft | 315 | 2.78521 | 1.39177 | 347 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 17 | 160 | 701.77 | L_Abluft | 110 | 1.51971 | 0.30279 | 220 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 29 | 200 | 601.867 | L_Abluft | 275 | 2.43153 | 1.12301 | 66 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 28 | 200 | 1171.44 | L_Abluft | 275 | 2.43153 | 0.936207 | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 160 | 598.182 | L_Abluft | 140 | 1.93417 | 0.413907 | 117 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 24 | 160 | 650.297 | L_Zuluft | 140 | 1.93417 | 0.449967 | 179 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 200 | 605.147 | L_Zuluft | 275 | 2.43153 | 1.12175 | 141 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 27 | 200 | 669.207 | L_Zuluft | 275 | 2.43153 | 0.797817 | 121 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 200 | 1014.87 | L_Abluft | 220 | 1.94523 | 0.515483 | 142 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 28 | 200 | 1009.31 | L_Zuluft | 220 | 1.94523 | 0.520119 | 105 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 6 | 200 | 538.342 | L_Zuluft | 250 | 2.21049 | 0.636053 | 231 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 5 | 200 | 559.931 | L_Zuluft | 250 | 2.21049 | 0.370944 | 251 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 7 | 200 | 536.947 | L_Abluft | 250 | 2.21049 | 0.665691 | 287 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 10 | 200 | 1291.21 | L_Zuluft | 240 | 2.12207 | 0.78942 | 215 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 200 | 625.192 | L_Abluft | 240 | 2.12207 | 0.50145 | 271 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 6 | 200 | 1153.66 | L_Abluft | 250 | 2.21049 | 0.764281 | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 200 | 592.608 | L_Abluft | 250 | 2.21049 | 0.392592 | 259 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 200 | 802.66 | L_Zuluft | 250 | 2.21049 | 0.531748 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 200 | 830.367 | L_Zuluft | 250 | 2.21049 | 0.550104 | 193 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 498.942 | L_Abluft | 250 | 2.21049 | 0.546783 | 222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 13 | 160 | 591.721 | L_Zuluft | 100 | 1.38155 | 0.214834 | 173 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 82 | 160 | 759.668 | L_Abluft | 235 | 3.24665 | 1.45839 | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 92 | 160 | 759.668 | L_Zuluft | 235 | 3.24665 | 1.45839 | 53 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 200 | 747.302 | L_Abluft | 245 | 2.16628 | 0.879994 | 123 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 25 | 200 | 701.999 | L_Zuluft | 245 | 2.16628 | 0.70901 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 200 | 703.058 | L_Zuluft | 245 | 2.16628 | 0.44762 | 61 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 27 | 200 | 380.061 | L_Abluft | 245 | 2.16628 | 0.241976 | 111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 23 | 200 | 1209.83 | L_Zuluft | 245 | 2.16628 | 0.77027 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 21 | 200 | 734.572 | L_Zuluft | 245 | 2.16628 | 0.467684 | 119 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 27 | 200 | 597.885 | L_Zuluft | 245 | 2.16628 | 0.380659 | 43 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 20 | 200 | 983.155 | L_Zuluft | 245 | 2.16628 | 0.625951 | 135 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 200 | 480.492 | L_Abluft | 245 | 2.16628 | 0.305917 | 164 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 28 | 200 | 775.482 | L_Abluft | 245 | 2.16628 | 0.49373 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 23 | 200 | 639.189 | L_Abluft | 245 | 2.16628 | 0.757407 | 154 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 200 | 1035.77 | L_Zuluft | 245 | 2.16628 | 0.659452 | 102 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 24 | 200 | 1190.07 | L_Abluft | 245 | 2.16628 | 0.757691 | 140 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 20 | 200 | 1276.33 | L_Abluft | 245 | 2.16628 | 0.812609 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 19 | 200 | 806.498 | L_Zuluft | 245 | 2.16628 | 0.513478 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 40 | 160 | 727.181 | L_Zuluft | 115 | 1.58879 | 0.342238 | 601 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 713.444 | L_Zuluft | 435 | 3.84624 | 1.72167 | 798 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 15 | 200 | 879.282 | L_Zuluft | 435 | 3.84624 | 1.7385 | 787 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 16 | 200 | 1206.23 | L_Zuluft | 435 | 3.84624 | 2.38494 | 776 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 15 | 200 | 798.131 | L_Abluft | 435 | 3.84624 | 1.57805 | 832 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 1022.19 | L_Abluft | 435 | 3.84624 | 2.02105 | 840 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 200 | 644.415 | L_Abluft | 180 | 1.59155 | 0.29839 | 897 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 13 | 200 | 793.417 | L_Abluft | 210 | 1.85681 | 0.373194 | 858 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 200 | 850.251 | L_Zuluft | 195 | 1.72418 | 0.345852 | 562 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 70 | 160 | 520.236 | L_Zuluft | 235 | 3.24665 | 0.998738 | 273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 83 | 160 | 423.842 | L_Abluft | 235 | 3.24665 | 0.813683 | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 91 | 160 | 572.464 | L_Zuluft | 235 | 3.24665 | 1.099 | 66 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 92 | 160 | 380.481 | L_Abluft | 235 | 3.24665 | 0.730439 | 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 12 | 160 | 472.166 | L_Zuluft | 110 | 1.51971 | 0.203724 | 838 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 10 | 160 | 534.808 | L_Zuluft | 130 | 1.79602 | 0.330251 | 870 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 32 | 160 | 478.875 | L_Abluft | 130 | 1.79602 | 0.286525 | 804 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 201 | 200 | 710.465 | L_Zuluft | 295 | 2.60837 | 0.647622 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 196 | 200 | 696.343 | L_Zuluft | 295 | 2.60837 | 0.62786 | 347 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 7 | 200 | 830.907 | L_Abluft | 450 | 3.97887 | 2.02216 | 632 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 160 | 667.551 | L_Zuluft | 160 | 2.21049 | 0.600482 | 405 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 31 | 160 | 848.33 | L_Abluft | 160 | 2.21049 | 0.763098 | 404 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 32 | 200 | 497.143 | L_Abluft | 320 | 2.82942 | 0.532489 | 386 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 11 | 160 | 789.373 | L_Zuluft | 110 | 1.51971 | 0.340588 | 853 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 51 | 160 | 1092.38 | L_Zuluft | 115 | 1.58879 | 0.514113 | 483 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 21 | 200 | 739.814 | L_Abluft | 245 | 2.16628 | 0.471022 | 188 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 47 | 200 | 565.563 | L_Abluft | 210 | 1.85681 | 0.26602 | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 34 | 200 | 925.156 | L_Abluft | 185 | 1.63576 | 0.339463 | 772 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 36 | 200 | 822.579 | L_Abluft | 185 | 1.63576 | 0.301825 | 748 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 36 | 160 | 613.594 | L_Zuluft | 130 | 1.79602 | 0.367131 | 666 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 57 | 200 | 715.569 | L_Abluft | 435 | 3.84624 | 1.41481 | 447 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 32 | 200 | 638.717 | L_Zuluft | 320 | 2.82942 | 0.688234 | 386 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 201 | 200 | 740.512 | L_Zuluft | 295 | 2.60837 | 0.647622 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 201 | 200 | 898.574 | L_Zuluft | 295 | 2.60837 | 0.647622 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 194 | 200 | 722.155 | L_Zuluft | 295 | 2.60837 | 0.908376 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 194 | 200 | 908.853 | L_Zuluft | 295 | 2.60837 | 0.908376 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 194 | 200 | 872.845 | L_Zuluft | 295 | 2.60837 | 0.908376 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 194 | 200 | 625.793 | L_Zuluft | 295 | 2.60837 | 0.908376 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 186 | 200 | 741.981 | L_Zuluft | 295 | 2.60837 | 0.904712 | 378 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 186 | 200 | 1043.8 | L_Zuluft | 295 | 2.60837 | 0.904712 | 378 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 176 | 200 | 695.431 | L_Zuluft | 295 | 2.60837 | 0.886759 | 410 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 176 | 200 | 1038.9 | L_Zuluft | 295 | 2.60837 | 0.886759 | 410 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 31 | 200 | 689.722 | L_Zuluft | 367 | 3.24499 | 0.974226 | 551 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 200 | 703.804 | L_Zuluft | 367 | 3.24499 | 0.994117 | 580 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 22 | 200 | 957.088 | L_Zuluft | 367 | 3.24499 | 1.35188 | 580 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 200 | 705.419 | L_Zuluft | 367 | 3.24499 | 0.996399 | 571 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 26 | 200 | 958.183 | L_Zuluft | 367 | 3.24499 | 1.35343 | 571 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 31 | 200 | 902.048 | L_Zuluft | 367 | 3.24499 | 1.27414 | 551 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr |  | 200 | 616.26 | L_Zuluft | 360 | 3.1831 | 0.837951
Flexrohr |  | 200 | 891.656 | L_Zuluft | 361 | 3.19194 | 1.21908
Flexrohr |  | 200 | 558.764 | L_Zuluft | 361 | 3.19194 | 0.763948
Flexrohr |  | 200 | 564.009 | L_Zuluft | 360 | 3.1831 | 0.766904
Flexrohr |  | 200 | 519.342 | L_Zuluft | 361 | 3.19194 | 0.71005
Flexrohr |  | 200 | 519.729 | L_Zuluft | 360 | 3.1831 | 0.706694
Flexrohr |  | 200 | 558.223 | L_Zuluft | 361 | 3.19194 | 0.763209
Flexrohr |  | 200 | 855.886 | L_Zuluft | 360 | 3.1831 | 1.16378
Flexrohr |  | 200 | 557.115 | L_Zuluft | 360 | 3.1831 | 0.757529
Flexrohr |  | 200 | 564.513 | L_Zuluft | 361 | 3.19194 | 0.771809
Flexrohr |  | 200 | 936.217 | L_Abluft | 450 | 3.97887 | 1.97962
Flexrohr |  | 200 | 970.978 | L_Abluft | 450 | 3.97887 | 2.05312
Flexrohr |  | 200 | 492.161 | L_Zuluft | 360 | 3.1831 | 0.669209
Flexrohr |  | 200 | 518.092 | L_Zuluft | 360 | 3.1831 | 0.704468
Flexrohr |  | 200 | 505.091 | L_Zuluft | 361 | 3.19194 | 0.690566
Flexrohr |  | 200 | 492.191 | L_Zuluft | 361 | 3.19194 | 0.672929
Flexrohr |  | 200 | 1009.51 | L_Zuluft | 360 | 3.1831 | 1.37267
Flexrohr |  | 200 | 747.39 | L_Zuluft | 361 | 3.19194 | 1.02184
Flexrohr |  | 200 | 748.027 | L_Zuluft | 360 | 3.1831 | 1.01712
Flexrohr |  | 200 | 748.614 | L_Zuluft | 361 | 3.19194 | 1.02351
Flexrohr |  | 200 | 551.231 | L_Zuluft | 360 | 3.1831 | 0.749528
Flexrohr |  | 200 | 552.134 | L_Zuluft | 361 | 3.19194 | 0.754884
Flexrohr |  | 200 | 672.129 | L_Zuluft | 360 | 3.1831 | 0.913918
Flexrohr |  | 200 | 684.055 | L_Zuluft | 361 | 3.19194 | 0.935248
Flexrohr |  | 200 | 668.736 | L_Zuluft | 360 | 3.1831 | 0.909305
Flexrohr |  | 200 | 704.487 | L_Zuluft | 361 | 3.19194 | 0.963183
Flexrohr |  | 200 | 746.695 | L_Zuluft | 360 | 3.1831 | 1.01531
Flexrohr |  | 200 | 762.453 | L_Zuluft | 361 | 3.19194 | 1.04243
Flexrohr |  | 200 | 751.776 | L_Zuluft | 360 | 3.1831 | 1.02222
Flexrohr |  | 200 | 1043.86 | L_Zuluft | 361 | 3.19194 | 1.42718
Flexrohr |  | 200 | 818.702 | L_Zuluft | 361 | 3.19194 | 1.11934
Flexrohr |  | 200 | 537.674 | L_Zuluft | 360 | 3.1831 | 0.731095
Flexrohr |  | 200 | 508.133 | L_Zuluft | 361 | 3.19194 | 0.694725
Flexrohr |  | 200 | 494.572 | L_Zuluft | 360 | 3.1831 | 0.672487
Flexrohr |  | 200 | 466.88 | L_Zuluft | 361 | 3.19194 | 0.638324
Flexrohr |  | 200 | 446.577 | L_Zuluft | 360 | 3.1831 | 0.607228
Flexrohr |  | 200 | 860.486 | L_Zuluft | 360 | 3.1831 | 1.17003
Flexrohr |  | 200 | 572.232 | L_Zuluft | 361 | 3.19194 | 0.782361
Flexrohr |  | 200 | 545.188 | L_Zuluft | 360 | 3.1831 | 0.741312
Flexrohr |  | 200 | 526.848 | L_Zuluft | 361 | 3.19194 | 0.720312
Flexrohr |  | 200 | 487.841 | L_Zuluft | 361 | 3.19194 | 0.666982
Flexrohr |  | 200 | 500.034 | L_Zuluft | 360 | 3.1831 | 0.679914
Flexrohr |  | 200 | 545.967 | L_Zuluft | 360 | 3.1831 | 0.742371
Flexrohr |  | 200 | 439.318 | L_Zuluft | 361 | 3.19194 | 0.600641
Flexrohr |  | 200 | 515.551 | L_Zuluft | 361 | 3.19194 | 0.704867
Flexrohr |  | 200 | 438.335 | L_Zuluft | 360 | 3.1831 | 0.59602
Flexrohr |  | 200 | 938.219 | L_Zuluft | 361 | 3.19194 | 1.28274
Flexrohr |  | 200 | 707.707 | L_Zuluft | 360 | 3.1831 | 0.962295
Flexrohr |  | 200 | 693.528 | L_Zuluft | 361 | 3.19194 | 0.9482
Flexrohr |  | 200 | 637.728 | L_Zuluft | 360 | 3.1831 | 0.867142
Flexrohr |  | 200 | 630.806 | L_Zuluft | 360 | 3.1831 | 0.857729
Flexrohr |  | 200 | 590.324 | L_Zuluft | 361 | 3.19194 | 0.807097
Flexrohr |  | 200 | 646.556 | L_Zuluft | 361 | 3.19194 | 0.951146
Flexrohr |  | 200 | 656.643 | L_Zuluft | 360 | 3.1831 | 0.960111
Flexrohr |  | 200 | 730.949 | L_Zuluft | 361 | 3.19194 | 1.05375
Flexrohr |  | 200 | 750.098 | L_Zuluft | 360 | 3.1831 | 1.05226
Flexrohr |  | 200 | 783.957 | L_Zuluft | 361 | 3.19194 | 1.10613
Flexrohr |  | 200 | 757.2 | L_Zuluft | 360 | 3.1831 | 1.06371
Flexrohr |  | 200 | 637.201 | L_Zuluft | 361 | 3.19194 | 1.14485
Flexrohr |  | 200 | 1039.03 | L_Zuluft | 360 | 3.1831 | 1.4287
Flexrohr |  | 200 | 872.641 | L_Abluft | 450 | 3.97887 | 1.84519
Flexrohr |  | 200 | 535.028 | L_Zuluft | 338 | 2.98858 | 0.642283
Flexrohr |  | 200 | 817.714 | L_Zuluft | 337 | 2.97973 | 0.975911
Flexrohr |  | 200 | 489.382 | L_Zuluft | 337 | 2.97973 | 0.584059
Flexrohr |  | 200 | 587.129 | L_Zuluft | 338 | 2.98858 | 0.704829
Flexrohr |  | 200 | 504.177 | L_Abluft | 450 | 3.97887 | 1.06044
Flexrohr |  | 200 | 503.111 | L_Abluft | 450 | 3.97887 | 1.06382
Flexrohr |  | 200 | 714.841 | L_Abluft | 450 | 3.97887 | 1.51152
Flexrohr |  | 200 | 788.199 | L_Abluft | 450 | 3.97887 | 1.66663
Flexrohr |  | 200 | 511.936 | L_Abluft | 450 | 3.97887 | 1.08248
Flexrohr |  | 200 | 534.039 | L_Abluft | 450 | 3.97887 | 1.16
Flexrohr |  | 200 | 952.623 | L_Zuluft
Flexrohr |  | 200 | 847.265 | L_Zuluft
Flexrohr |  | 200 | 914.911 | L_Zuluft
Flexrohr |  | 200 | 777.066 | L_Zuluft
Flexrohr |  | 200 | 1002.35 | L_Zuluft
Flexrohr |  | 200 | 825.72 | L_Zuluft
Flexrohr |  | 200 | 998.196 | L_Zuluft
Flexrohr |  | 200 | 788.559 | L_Zuluft
Flexrohr |  | 200 | 723.444 | L_Abluft | 450 | 3.97887 | 1.53229
Flexrohr |  | 200 | 744.471 | L_Abluft | 450 | 3.97887 | 1.57417
Flexrohr |  | 200 | 865.114 | L_Abluft | 450 | 3.97887 | 1.82927
Flexrohr |  | 200 | 1015.2 | L_Zuluft
Flexrohr |  | 200 | 599.057 | L_Zuluft
Flexrohr |  | 200 | 448.548 | L_Zuluft
Flexrohr |  | 200 | 495.672 | L_Zuluft
Flexrohr |  | 200 | 440.516 | L_Zuluft
Flexrohr |  | 200 | 452.477 | L_Zuluft
Flexrohr | 13 | 160 | 463.754 | L_Abluft | 100 | 1.38155 | 0.214834 | 173 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 88 | 160 | 327.809 | L_Zuluft | 140 | 1.93417 | 0.431384 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 14 | 200 | 1087.57 | L_Abluft | 435 | 3.84624 | 1.72167 | 798 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Flexrohr | 58 | 200 | 464.387 | L_Abluft | 435 | 3.84624 | 2.2547 | 437 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II

# IfcFlowSegment: Kanalstutzen (18)
Description: Kanalstutzen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 50 mm; Geom-Surface (m2): 1 m2; Tech-Material (ID): 1; Name: Kanalstutzen; Abbreviation: LT
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Tech-Medium | Tech-Weight (kg) (kg) | Pos. No. | Floor | Floor No. | Building = Building No.
Kanalstutzen | Wartung_FFB | 59 | 650 | 500 | L_Zuluft | 0.736 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | Wartung_FFB | 60 | 650 | 500 | L_Abluft | 0.736 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | Wartung_FFB | 13 | 500 | 1400 | L_Abluft | 1.52 | 120 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | Wartung_FFB | 19 | 500 | 1400 | L_Abluft | 1.52 | 92 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | Wartung_FFB | 6 | 600 | 500 | L_Zuluft | 0.704 | 519 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | Wartung_FFB |  | 500 | 300 | L_Abluft | 0.384
Kanalstutzen | Wartung_FFB |  | 400 | 500 | L_Zuluft | 0.432
Kanalstutzen | Wartung_FFB |  | 350 | 450 | L_Zuluft | 0.384
Kanalstutzen | EG_Verwaltung_FFB | 25 | 200 | 200 | L_Abluft | 0.192 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 15 | 200 | 200 | L_Abluft | 0.192 | 484 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 10 | 200 | 200 | L_Abluft | 0.192 | 503 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 11 | 200 | 200 | L_Abluft | 0.192 | 497 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 24 | 200 | 200 | L_Zuluft | 0.192 | 46 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB |  | 200 | 200 | L_Zuluft | 0.192 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 24 | 200 | 350 | L_Zuluft | 0.264 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 33 | 200 | 350 | L_Abluft | 0.264 | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 20 | 400 | 200 | L_Zuluft | 0.288 | 74 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Kanalstutzen | EG_Verwaltung_FFB | 21 | 400 | 200 | L_Abluft | 0.288 | 35 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II

# IfcFlowSegment: Luftleitung (1382)
Description: Luftleitung
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Luftleitung; Abbreviation: L
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitung | Wartung_FFB | 59 | 650 | 500 | 1500 | 3.45 | L_Zuluft | 22.08 | 4380 | 3.74359 | 0.409549 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 60 | 650 | 500 | 1500 | 3.45 | L_Abluft | 22.08 | 4380 | 3.74359 | 0.409549 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 400 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 70 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Abluft | 12.96 | 2590 | 3.59722 | 0.510159 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 400 | 1500 | 2.7 | L_Zuluft | 12.96 | 2530 | 3.51389 | 0.488477 | 69 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 500 | 700 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 320 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 700 | 600 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 411 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 378 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 367 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 366 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 365 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 364 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 363 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 362 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 361 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 360 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 359 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 59 | 650 | 500 | 972.677 | 2.23716 | L_Zuluft | 14.3178 | 4380 | 3.74359 | 0.265572 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 358 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 700 | 600 | 1500 | 3.9 | L_Zuluft | 24.96 | 5740 | 3.7963 | 0.35717 | 357 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 1530 | 918 | 1112.75 | 5.44804 | L_Aussenluft | 43.5843 | 10190 | 2.01529 | 0.0409867 | 875 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 1530 | 918 | 917.999 | 4.49452 | L_Aussenluft | 35.9562 | 10190 | 2.01529 | 0.0338132 | 879 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 887 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 888 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 898 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 899 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1000 | 3.6 | L_Aussenluft | 23.04 | 10190 | 3.49451 | 0.136596 | 900 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 924.897 | 3.32963 | L_Aussenluft | 21.3096 | 10190 | 3.49451 | 0.126337 | 901 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 903 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 904 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 905 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 906 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 907 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 908 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 909 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 910 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 911 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1500 | 5.4 | L_Aussenluft | 34.56 | 10190 | 3.49451 | 0.204894 | 912 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1139.56 | 4.1024 | L_Aussenluft | 26.2554 | 10190 | 3.49451 | 0.155659 | 913 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1000 | 3.6 | L_Fortluft | 23.04 | 10190 | 3.49451 | 0.136596 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1222.11 | 4.3996 | L_Zuluft | 28.1574 | 10120 | 3.47051 | 0.16481 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1222.11 | 4.3996 | L_Abluft | 28.1574 | 10190 | 3.49451 | 0.166935 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 60 | 650 | 500 | 1372.68 | 3.15716 | L_Abluft | 20.2058 | 4380 | 3.74359 | 0.374785 | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 52 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 51 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 50 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 49 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1530 | 918 | 1112.75 | 5.44804 | L_Abluft | 43.5843 | 10190 | 2.01529 | 0.0409867 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 386 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 387 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 388 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 389 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 390 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 391 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 392 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 393 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 394 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 395 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 396 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 397 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 398 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1035.08 | 2.6912 | L_Abluft | 17.2237 | 5810 | 3.84259 | 0.252086 | 399 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1460.43 | 3.50502 | L_Abluft | 22.4321 | 4961 | 3.9373 | 0.42147 | 467 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Zuluft | 14.4 | 3300 | 3.66667 | 0.457651 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Zuluft | 14.4 | 3300 | 3.66667 | 0.457651 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Zuluft | 14.4 | 3300 | 3.66667 | 0.457651 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1347 | 2.694 | L_Zuluft | 12.9312 | 3300 | 3.66667 | 0.410971 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 62 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 612 | 918 | 918 | 2.80908 | L_Aussenluft | 17.9781 | 3300 | 1.63161 | 0.0395426 | 260 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 49 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 50 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 51 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 52 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1500 | 3 | L_Abluft | 14.4 | 3300 | 3.66667 | 0.457651 | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 956.091 | 1.91218 | L_Abluft | 9.17848 | 3300 | 3.66667 | 0.291704 | 58 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Zuluft | 14.4 | 3300 | 3.66667 | 0.457651 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 281 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 280 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 279 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 278 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 277 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 276 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 275 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 274 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 273 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 272 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 271 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 270 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 269 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 386 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 385 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 384 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 383 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 382 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 381 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 380 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 379 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 378 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 377 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 376 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 500 | 400 | 1000 | 1.8 | L_Fortluft | 8.64 | 2530 | 3.51389 | 0.325651 | 375 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 400 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
