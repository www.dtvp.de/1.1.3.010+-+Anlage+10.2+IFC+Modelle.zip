Properties of the parts of a building model (IFC2X3), part 14 of 18

# IfcFlowSegment: Wickelfalzrohr (1462)
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 100 | 980.97 | L_Abluft | 110 | 3.89045 | 2.46742 | 678 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 126.313 | L_Zuluft | 110 | 3.89045 | 0.317712 | 624 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 56 | 125 | 980.97 | L_Abluft | 120 | 2.71624 | 0.963364 | 462 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 1043.9 | L_Zuluft | 60 | 2.12207 | 0.869888 | 557 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 1187.31 | L_Zuluft | 60 | 2.12207 | 0.989397 | 559 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 896.15 | L_Zuluft | 60 | 2.12207 | 0.74677 | 561 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 341.13 | L_Abluft | 60 | 2.12207 | 0.284267 | 607 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 882.534 | L_Abluft | 60 | 2.12207 | 0.735423 | 613 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 1126.43 | L_Zuluft | 60 | 2.12207 | 0.938664 | 563 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 140 | 311.835 | L_Zuluft | 200 | 3.60896 | 0.44682 | 678 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 140 | 200 | L_Abluft | 200 | 3.60896 | 0.286574 | 731 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 140 | 829.163 | L_Zuluft | 200 | 3.60896 | 1.18808 | 680 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 140 | 1208.17 | L_Zuluft | 200 | 3.60896 | 1.73115 | 682 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 339.913 | L_Zuluft | 110 | 2.48989 | 0.284945 | 730 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 688.822 | L_Abluft | 110 | 2.48989 | 0.577433 | 782 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 858.718 | L_Abluft | 110 | 2.48989 | 0.719855 | 784 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 335.551 | L_Abluft | 110 | 2.48989 | 0.281289 | 786 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 125 | 500.001 | L_Zuluft | 130 | 2.9426 | 0.568248 | 763 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 200 | L_Abluft | 130 | 2.9426 | 0.227299 | 798 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 140 | 1169.08 | L_Abluft | 185 | 3.33828 | 1.45139 | 744 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 458.303 | L_Zuluft | 185 | 3.33828 | 0.568975 | 696 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 1169.08 | L_Abluft | 185 | 3.33828 | 1.45139 | 768 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 140 | 458.303 | L_Zuluft | 185 | 3.33828 | 0.568975 | 742 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 379.833 | L_Abluft | 60 | 2.12207 | 0.316518 | 575 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 514.186 | L_Zuluft | 60 | 2.12207 | 0.428476 | 537 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 516.522 | L_Zuluft | 60 | 2.12207 | 0.430423 | 539 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 48 | 100 | 1712.3 | L_Zuluft | 60 | 2.12207 | 1.42687 | 541 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 317.193 | L_Abluft | 60 | 2.12207 | 0.26432 | 577 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 162.055 | L_Abluft | 60 | 2.12207 | 0.135042 | 579 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 50 | 100 | 265.407 | L_Abluft | 60 | 2.12207 | 0.221166 | 581 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 125 | 376.785 | L_Abluft | 130 | 2.9426 | 0.428213 | 714 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 125 | 1327.1 | L_Abluft | 130 | 2.9426 | 1.50824 | 716 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 482.402 | L_Zuluft | 220 | 3.03942 | 0.426387 | 588 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 160 | 97.5 | L_Abluft | 220 | 3.03942 | 0.0861786 | 646 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 160 | 169.102 | L_Abluft | 220 | 3.03942 | 0.149467 | 642 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 160 | 104.938 | L_Abluft | 220 | 3.03942 | 0.092753 | 644 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 482.402 | L_Zuluft | 220 | 3.03942 | 0.426387 | 611 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 97.5 | L_Abluft | 220 | 3.03942 | 0.0861786 | 667 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 169.102 | L_Abluft | 220 | 3.03942 | 0.149467 | 663 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 104.938 | L_Abluft | 220 | 3.03942 | 0.092753 | 665 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 100 | 120.391 | L_Abluft | 80 | 2.82942 | 0.168976 | 516 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 225.872 | L_Zuluft | 80 | 2.82942 | 0.317025 | 462 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 100 | 519.573 | L_Abluft | 60 | 2.12207 | 0.432965 | 559 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 100 | 227.086 | L_Zuluft | 60 | 2.12207 | 0.189233 | 519 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 125 | 249.7 | L_Zuluft | 130 | 2.9426 | 0.283783 | 661 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 140 | 1430.91 | L_Zuluft | 200 | 3.60896 | 2.05031 | 676 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 970.766 | L_Zuluft | 185 | 3.33828 | 1.20519 | 694 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 1445.91 | L_Zuluft | 110 | 2.48989 | 1.21209 | 724 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 735.05 | L_Zuluft | 110 | 2.48989 | 0.616185 | 722 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 140 | 715.05 | L_Zuluft | 185 | 3.33828 | 0.887721 | 738 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 140 | 970.766 | L_Zuluft | 185 | 3.33828 | 1.20519 | 740 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 125 | 5126.19 | L_Zuluft | 130 | 2.9426 | 5.82588 | 757 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 125 | 455.05 | L_Zuluft | 130 | 2.9426 | 0.517161 | 755 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 125 | 2722 | L_Zuluft | 130 | 2.9426 | 3.09353 | 753 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 735.05 | L_Abluft | 110 | 2.48989 | 0.616185 | 776 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 2367.56 | L_Abluft | 130 | 2.9426 | 2.69071 | 792 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 455.05 | L_Abluft | 130 | 2.9426 | 0.517161 | 794 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 31 | 200 | 535.169 | L_Abluft | 240 | 2.12207 | 0.185747 | 774 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 715.05 | L_Abluft | 185 | 3.33828 | 0.887721 | 764 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 140 | 1370.77 | L_Abluft | 185 | 3.33828 | 1.70178 | 742 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 140 | 1030.91 | L_Abluft | 200 | 3.60896 | 1.47716 | 729 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 1370.77 | L_Abluft | 185 | 3.33828 | 1.70178 | 766 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 1045.91 | L_Abluft | 110 | 2.48989 | 0.876775 | 778 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 32 | 125 | 566.522 | L_Abluft | 130 | 2.9426 | 0.643848 | 796 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 200 | 3460.15 | L_Abluft | 425 | 3.75783 | 3.41952 | 762 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 160 | 3312.09 | L_Zuluft | 180 | 2.4868 | 2.02918 | 506 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 125 | 492.38 | L_Zuluft | 120 | 2.71624 | 0.483543 | 527 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 100 | 2229.52 | L_Zuluft | 60 | 2.12207 | 1.85788 | 547 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 125 | 498.016 | L_Zuluft | 120 | 2.71624 | 0.489078 | 440 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 56 | 125 | 452.435 | L_Abluft | 120 | 2.71624 | 0.444315 | 464 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 125 | 498.016 | L_Abluft | 140 | 3.16895 | 0.648178 | 626 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 125 | 980.97 | L_Zuluft | 140 | 3.16895 | 1.27675 | 576 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 100 | 346.125 | L_Abluft | 110 | 3.89045 | 0.870603 | 680 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 498.016 | L_Zuluft | 110 | 3.89045 | 1.25265 | 621 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 140 | 715.05 | L_Abluft | 185 | 3.33828 | 0.887721 | 740 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 140 | 665.05 | L_Zuluft | 200 | 3.60896 | 0.952931 | 674 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 140 | 665.05 | L_Abluft | 200 | 3.60896 | 0.952931 | 727 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 125 | 647.879 | L_Zuluft | 130 | 2.9426 | 0.73631 | 657 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 160 | 195.05 | L_Zuluft | 220 | 3.03942 | 0.172401 | 635 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 160 | 4483.34 | L_Zuluft | 220 | 3.03942 | 3.96275 | 637 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 195.05 | L_Abluft | 220 | 3.03942 | 0.172401 | 690 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 3793.82 | L_Abluft | 220 | 3.03942 | 3.35329 | 692 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 2839.03 | L_Zuluft | 110 | 3.89045 | 7.14097 | 619 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 1795 | L_Zuluft | 220 | 3.03942 | 1.58657 | 609 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 100 | 2339.03 | L_Abluft | 110 | 3.89045 | 5.88333 | 676 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 2295 | L_Abluft | 220 | 3.03942 | 2.02851 | 659 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 41 | 160 | 1795 | L_Zuluft | 220 | 3.03942 | 1.58657 | 586 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 160 | 2295 | L_Abluft | 220 | 3.03942 | 2.02851 | 638 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 43 | 125 | 2314.03 | L_Abluft | 140 | 3.16895 | 3.01176 | 624 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 42 | 125 | 2814.03 | L_Zuluft | 140 | 3.16895 | 3.66252 | 574 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 160 | 164.717 | L_Abluft | 220 | 3.03942 | 0.14559 | 701 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 53 | 100 | 423.892 | L_Abluft | 80 | 2.82942 | 0.594959 | 518 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 556.647 | L_Zuluft | 80 | 2.82942 | 0.78129 | 465 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 95.8345 | L_Abluft | 110 | 3.89045 | 0.241051 | 871 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 136.062 | L_Abluft | 110 | 3.89045 | 0.342234 | 873 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 316.405 | L_Abluft | 110 | 3.89045 | 0.795848 | 869 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 771.845 | L_Zuluft | 110 | 3.89045 | 1.94141 | 832 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 267.781 | L_Zuluft | 130 | 2.9426 | 0.304331 | 863 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 161.866 | L_Abluft | 130 | 2.9426 | 0.18396 | 909 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 5420.9 | L_Abluft | 130 | 2.9426 | 6.16082 | 907 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 196.844 | L_Zuluft | 210 | 3.7894 | 0.308589 | 817 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 5774.49 | L_Abluft | 210 | 3.7894 | 9.0526 | 852 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 420.804 | L_Abluft | 180 | 3.24806 | 0.496793 | 891 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 563.657 | L_Abluft | 180 | 3.24806 | 0.665443 | 889 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 125 | 258.782 | L_Abluft | 140 | 3.16895 | 0.33681 | 142 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 125 | 293.782 | L_Abluft | 140 | 3.16895 | 0.382364 | 147 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 125 | 200 | L_Abluft | 140 | 3.16895 | 0.260304 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 65 | 125 | 580.502 | L_Zuluft | 140 | 3.16895 | 0.755536 | 336 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 100 | 543 | L_Abluft | 40 | 1.41471 | 0.218928 | 165 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 100 | 315.426 | L_Abluft | 40 | 1.41471 | 0.127174 | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 63 | 100 | 543 | L_Zuluft | 40 | 1.41471 | 0.218928 | 353 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 99.6742 | L_Abluft | 70 | 2.47574 | 0.109756 | 132 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 48.9683 | L_Abluft | 70 | 2.47574 | 0.0539215 | 121 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 100 | 202.968 | L_Abluft | 90 | 3.1831 | 0.353199 | 107 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 100 | 130 | L_Abluft | 90 | 3.1831 | 0.226222 | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 100 | 737.5 | L_Abluft | 90 | 3.1831 | 1.28337 | 115 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 68 | 100 | 165.48 | L_Zuluft | 90 | 3.1831 | 0.287962 | 309 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 68 | 100 | 443.601 | L_Zuluft | 90 | 3.1831 | 0.771941 | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 63 | 100 | 756.506 | L_Zuluft | 40 | 1.41471 | 0.30501 | 347 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 63 | 100 | 229.187 | L_Zuluft | 40 | 1.41471 | 0.0924042 | 349 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 67 | 100 | 99.6742 | L_Zuluft | 70 | 2.47574 | 0.109756 | 328 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 67 | 100 | 936.265 | L_Zuluft | 70 | 2.47574 | 1.03097 | 323 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 67 | 100 | 304.656 | L_Zuluft | 70 | 2.47574 | 0.335473 | 321 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 67 | 100 | 194.063 | L_Zuluft | 70 | 2.47574 | 0.213693 | 319 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 89 | 125 | 123.756 | L_Abluft | 160 | 3.62166 | 0.205825 | 103 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 89 | 125 | 2077.93 | L_Abluft | 160 | 3.62166 | 3.45592 | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 86 | 180 | 307.724 | L_Abluft | 180 | 1.96488 | 0.106041 | 136 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 125 | 1737.07 | L_Abluft | 140 | 3.16895 | 2.26084 | 140 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 100 | 430.806 | L_Abluft | 40 | 1.41471 | 0.173693 | 155 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 100 | 1756.51 | L_Abluft | 40 | 1.41471 | 0.708192 | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 67 | 100 | 1433.6 | L_Zuluft | 70 | 2.47574 | 1.57862 | 315 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 68 | 100 | 168 | L_Zuluft | 90 | 3.1831 | 0.292348 | 311 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 67 | 100 | 168 | L_Zuluft | 70 | 2.47574 | 0.184994 | 330 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 100 | 168 | L_Abluft | 90 | 3.1831 | 0.292348 | 117 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 100 | 168 | L_Abluft | 70 | 2.47574 | 0.184994 | 134 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 125 | 115 | L_Abluft | 140 | 3.16895 | 0.149675 | 138 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 89 | 125 | 115 | L_Abluft | 160 | 3.62166 | 0.191263 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 65 | 125 | 1241.07 | L_Zuluft | 140 | 3.16895 | 1.61528 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 66 | 125 | 145.825 | L_Zuluft | 160 | 3.62166 | 0.242531 | 297 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 125 | 137.32 | L_Abluft | 120 | 2.71624 | 0.134855 | 223 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 125 | 233.677 | L_Abluft | 120 | 2.71624 | 0.229483 | 220 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 89 | 125 | 233.677 | L_Zuluft | 120 | 2.71624 | 0.229483 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 78 | 140 | 218.677 | L_Abluft | 170 | 3.06761 | 0.232485 | 252 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 140 | 218.677 | L_Zuluft | 170 | 3.06761 | 0.232485 | 126 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 73 | 125 | 137.32 | L_Abluft | 140 | 3.16895 | 0.178725 | 334 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 73 | 125 | 233.677 | L_Abluft | 140 | 3.16895 | 0.304136 | 331 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 125 | 233.677 | L_Zuluft | 140 | 3.16895 | 0.304136 | 190 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 125 | 152.032 | L_Zuluft | 140 | 3.16895 | 0.197873 | 193 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 217.056 | L_Zuluft | 250 | 3.45388 | 0.242615 | 204 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 348.261 | L_Zuluft | 250 | 3.45388 | 0.389271 | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 348.093 | L_Zuluft | 250 | 3.45388 | 0.389083 | 206 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 74 | 160 | 217.056 | L_Abluft | 250 | 3.45388 | 0.242615 | 316 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 74 | 160 | 386.422 | L_Abluft | 250 | 3.45388 | 0.431926 | 318 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 74 | 160 | 315.465 | L_Abluft | 250 | 3.45388 | 0.352613 | 320 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 200 | 262.893 | L_Zuluft | 440 | 3.89045 | 0.277013 | 222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 200 | 275.168 | L_Zuluft | 435 | 3.84624 | 0.283883 | 252 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 200 | 275.043 | L_Zuluft | 435 | 3.84624 | 0.283754 | 254 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 200 | 228.041 | L_Zuluft | 435 | 3.84624 | 0.235263 | 256 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 200 | 1496 | L_Abluft | 435 | 3.84624 | 1.54338 | 380 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 200 | 275.168 | L_Abluft | 435 | 3.84624 | 0.283883 | 378 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 200 | 374.019 | L_Abluft | 435 | 3.84624 | 0.385865 | 382 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 200 | 697.347 | L_Zuluft | 435 | 3.84624 | 0.719433 | 240 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 200 | 123.194 | L_Zuluft | 435 | 3.84624 | 0.127096 | 238 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 71 | 200 | 1421.98 | L_Abluft | 435 | 3.84624 | 1.46702 | 367 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 71 | 200 | 123.194 | L_Abluft | 435 | 3.84624 | 0.127096 | 365 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 200 | 1412.57 | L_Zuluft | 435 | 3.84624 | 1.45731 | 236 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 71 | 200 | 1812.56 | L_Abluft | 435 | 3.84624 | 1.86997 | 363 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 200 | 1629.15 | L_Abluft | 435 | 3.84624 | 1.68075 | 372 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 200 | 2133.07 | L_Abluft | 435 | 3.84624 | 2.20063 | 376 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 200 | 2259.51 | L_Zuluft | 435 | 3.84624 | 2.33107 | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 200 | 2533.07 | L_Zuluft | 435 | 3.84624 | 2.61329 | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 72 | 200 | 299.851 | L_Abluft | 440 | 3.89045 | 0.315956 | 350 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 72 | 200 | 1890.76 | L_Abluft | 440 | 3.89045 | 1.99232 | 346 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 200 | 901.053 | L_Zuluft | 440 | 3.89045 | 0.94945 | 220 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 73 | 125 | 2758.7 | L_Abluft | 140 | 3.16895 | 3.5905 | 329 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 74 | 160 | 474.75 | L_Abluft | 250 | 3.45388 | 0.530654 | 314 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 1024.75 | L_Zuluft | 250 | 3.45388 | 1.14542 | 202 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 125 | 2208.7 | L_Zuluft | 140 | 3.16895 | 2.87467 | 188 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 75 | 160 | 3509.12 | L_Abluft | 270 | 3.73019 | 4.51997 | 298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 84 | 160 | 2959.13 | L_Zuluft | 270 | 3.73019 | 3.81154 | 172 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 85 | 180 | 2460.54 | L_Zuluft | 300 | 3.27479 | 2.15199 | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 76 | 180 | 1910.54 | L_Abluft | 300 | 3.27479 | 1.67096 | 283 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 86 | 140 | 203.335 | L_Zuluft | 200 | 3.60896 | 0.291353 | 141 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 77 | 140 | 278.625 | L_Abluft | 200 | 3.60896 | 0.399235 | 267 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 87 | 140 | 2168.7 | L_Zuluft | 170 | 3.06761 | 2.30564 | 124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 78 | 140 | 2768.7 | L_Abluft | 170 | 3.06761 | 2.94352 | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 86 | 140 | 2525.54 | L_Zuluft | 200 | 3.60896 | 3.61877 | 137 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 77 | 140 | 1925.54 | L_Abluft | 200 | 3.60896 | 2.75905 | 263 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 140 | 278.625 | L_Abluft | 180 | 3.24806 | 0.32894 | 236 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 89 | 125 | 2158.7 | L_Zuluft | 120 | 2.71624 | 2.11996 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 80 | 125 | 2808.7 | L_Abluft | 120 | 2.71624 | 2.75829 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 88 | 140 | 1207.48 | L_Zuluft | 180 | 3.24806 | 1.42553 | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 79 | 140 | 557.487 | L_Abluft | 180 | 3.24806 | 0.658159 | 232 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 190.294 | L_Zuluft | 235 | 3.24665 | 0.189832 | 47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 190.294 | L_Abluft | 235 | 3.24665 | 0.189832 | 189 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 69 | 160 | 190.294 | L_Zuluft | 235 | 3.24665 | 0.189832 | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 93 | 160 | 190.294 | L_Abluft | 235 | 3.24665 | 0.189832 | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 160 | 190.294 | L_Zuluft | 235 | 3.24665 | 0.189832 | 269 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 190.294 | L_Abluft | 235 | 3.24665 | 0.189832 | 83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 160 | 190.294 | L_Zuluft | 235 | 3.24665 | 0.189832 | 60 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 160 | 190.294 | L_Abluft | 235 | 3.24665 | 0.189832 | 174 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 160 | 131.497 | L_Zuluft | 235 | 3.24665 | 0.131178 | 63 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 160 | 197.211 | L_Abluft | 235 | 3.24665 | 0.196732 | 177 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 552.46 | L_Zuluft | 160 | 3.62166 | 0.918829 | 78 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 3819.68 | L_Zuluft | 160 | 3.62166 | 6.35273 | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 125 | 202.85 | L_Abluft | 160 | 3.62166 | 0.337371 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 125 | 415 | L_Abluft | 160 | 3.62166 | 0.690211 | 205 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 81 | 125 | 3594.47 | L_Abluft | 160 | 3.62166 | 5.97817 | 201 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 710.075 | L_Zuluft | 160 | 3.62166 | 1.18097 | 76 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 6000 | L_Zuluft | 160 | 3.62166 | 9.97895 | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 6000 | L_Zuluft | 160 | 3.62166 | 9.97895 | 81 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 90 | 125 | 411.24 | L_Zuluft | 160 | 3.62166 | 0.683957 | 82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 91 | 160 | 1951.3 | L_Zuluft | 235 | 3.24665 | 1.94657 | 58 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 1378.95 | L_Zuluft | 235 | 3.24665 | 1.3756 | 45 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 82 | 160 | 2028.94 | L_Abluft | 235 | 3.24665 | 2.02402 | 187 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 83 | 160 | 1301.3 | L_Abluft | 235 | 3.24665 | 1.29815 | 172 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 85 | 180 | 250.161 | L_Abluft | 340 | 3.71143 | 0.275532 | 97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 92 | 160 | 1401.3 | L_Abluft | 235 | 3.24665 | 1.3979 | 81 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 69 | 160 | 1478.95 | L_Zuluft | 235 | 3.24665 | 1.47536 | 278 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 70 | 160 | 1851.3 | L_Zuluft | 235 | 3.24665 | 1.84681 | 267 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 93 | 160 | 1928.94 | L_Abluft | 235 | 3.24665 | 1.92426 | 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 450.05 | L_Zuluft | 110 | 1.98493 | 0.21685 | 844 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 100 | 485.05 | L_Zuluft | 110 | 3.89045 | 1.22004 | 828 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 140 | 457.595 | L_Abluft | 180 | 3.24806 | 0.540228 | 885 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 180 | 360.219 | L_Abluft | 310 | 3.38395 | 0.334636 | 881 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 8 | 200 | 966.288 | L_Zuluft | 350 | 3.09468 | 0.667798 | 826 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 8 | 200 | 652.744 | L_Abluft | 420 | 3.71362 | 0.631127 | 861 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 2679.27 | L_Abluft | 210 | 3.7894 | 4.20025 | 850 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 1577.56 | L_Abluft | 435 | 3.84624 | 1.62752 | 827 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 1257.28 | L_Abluft | 435 | 3.84624 | 1.2971 | 839 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 229.587 | L_Abluft | 435 | 3.84624 | 0.236858 | 829 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 58 | 200 | 1763.9 | L_Abluft | 435 | 3.84624 | 1.81976 | 436 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 127.915 | L_Zuluft | 435 | 3.84624 | 0.131966 | 401 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 58 | 200 | 2309.39 | L_Zuluft | 435 | 3.84624 | 2.38253 | 393 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 58 | 200 | 648.61 | L_Zuluft | 435 | 3.84624 | 0.669153 | 395 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 157.703 | L_Zuluft | 435 | 3.84624 | 0.162697 | 404 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 200 | 208.472 | L_Zuluft | 435 | 3.84624 | 0.215075 | 409 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 200 | 132.51 | L_Zuluft | 435 | 3.84624 | 0.136707 | 411 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 55 | 200 | 232.703 | L_Zuluft | 435 | 3.84624 | 0.240073 | 414 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 136.021 | L_Zuluft | 130 | 2.9426 | 0.154587 | 865 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 201.275 | L_Abluft | 435 | 3.84624 | 0.20765 | 440 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 58 | 200 | 201.275 | L_Abluft | 435 | 3.84624 | 0.20765 | 431 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 58 | 200 | 1059.96 | L_Zuluft | 435 | 3.84624 | 1.09353 | 391 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 57 | 200 | 1059.96 | L_Zuluft | 435 | 3.84624 | 1.09353 | 399 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 150.064 | L_Zuluft | 50 | 1.13177 | 0.030595 | 714 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 200 | 2510.91 | L_Zuluft | 425 | 3.75783 | 2.48142 | 720 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 153.868 | L_Zuluft | 50 | 1.13177 | 0.0313705 | 712 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 730.05 | L_Zuluft | 50 | 1.13177 | 0.148842 | 708 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 33 | 125 | 426.778 | L_Zuluft | 50 | 1.13177 | 0.0870113 | 710 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 125 | 163.199 | L_Abluft | 50 | 1.13177 | 0.0332729 | 756 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 715.05 | L_Zuluft | 185 | 3.33828 | 0.887721 | 692 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 35 | 125 | 730.05 | L_Abluft | 50 | 1.13177 | 0.148842 | 752 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 54 | 100 | 123.049 | L_Abluft | 85 | 3.00626 | 0.192895 | 496 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 140 | 465.894 | L_Abluft | 205 | 3.69918 | 0.698635 | 565 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 45 | 160 | 3655.06 | L_Abluft | 265 | 3.66112 | 4.54839 | 545 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 52 | 100 | 240.05 | L_Abluft | 60 | 2.12207 | 0.200036 | 527 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 125 | 215.05 | L_Zuluft | 115 | 2.60307 | 0.195449 | 474 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 51 | 125 | 285.412 | L_Zuluft | 115 | 2.60307 | 0.259398 | 476 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 140 | 342.259 | L_Abluft | 195 | 3.51873 | 0.468083 | 564 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 140 | 342.259 | L_Zuluft | 195 | 3.51873 | 0.468083 | 532 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 6000 | L_Zuluft | 385 | 3.40415 | 4.94105 | 538 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 6000 | L_Zuluft | 385 | 3.40415 | 4.94105 | 539 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 140 | 342.259 | L_Zuluft | 190 | 3.42851 | 0.446248 | 548 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 3200.9 | L_Zuluft | 385 | 3.40415 | 2.63597 | 540 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 140 | 6000 | L_Zuluft | 195 | 3.51873 | 8.20577 | 555 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 140 | 6000 | L_Zuluft | 195 | 3.51873 | 8.20577 | 556 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 140 | 342.259 | L_Zuluft | 195 | 3.51873 | 0.468083 | 559 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 140 | 342.259 | L_Abluft | 195 | 3.51873 | 0.468083 | 533 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 24 | 140 | 395 | L_Abluft | 195 | 3.51873 | 0.540213 | 529 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 200 | 6000 | L_Abluft | 385 | 3.40415 | 4.94105 | 539 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 200 | 6000 | L_Abluft | 385 | 3.40415 | 4.94105 | 540 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 23 | 140 | 342.259 | L_Abluft | 190 | 3.42851 | 0.446248 | 549 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 200 | 3242.93 | L_Abluft | 385 | 3.40415 | 2.67058 | 541 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 140 | 6000 | L_Abluft | 195 | 3.51873 | 8.20577 | 556 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 22 | 140 | 6000 | L_Abluft | 195 | 3.51873 | 8.20577 | 557 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 25 | 140 | 342.259 | L_Abluft | 190 | 3.42851 | 0.446248 | 500 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 26 | 140 | 342.259 | L_Abluft | 190 | 3.42851 | 0.446248 | 481 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 140 | 342.259 | L_Zuluft | 190 | 3.42851 | 0.446248 | 502 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 20 | 140 | 342.259 | L_Zuluft | 190 | 3.42851 | 0.446248 | 447 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 140 | 342.259 | L_Abluft | 190 | 3.42851 | 0.446248 | 442 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 140 | 342.259 | L_Zuluft | 190 | 3.42851 | 0.446248 | 462 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 342.259 | L_Zuluft | 190 | 3.42851 | 0.446248 | 485 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 342.259 | L_Abluft | 190 | 3.42851 | 0.446248 | 466 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 200 | 3242.93 | L_Zuluft | 380 | 3.35994 | 2.60706 | 454 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 19 | 140 | 85 | L_Zuluft | 190 | 3.42851 | 0.110826 | 456 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 29 | 140 | 85 | L_Abluft | 190 | 3.42851 | 0.110826 | 436 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 6000 | L_Abluft | 190 | 3.42851 | 7.82299 | 449 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 4114.36 | L_Abluft | 190 | 3.42851 | 5.36443 | 450 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 18 | 140 | 3354.35 | L_Zuluft | 190 | 3.42851 | 4.37351 | 469 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 200 | 6000 | L_Abluft | 380 | 3.35994 | 4.82352 | 434 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 17 | 200 | 4806.51 | L_Zuluft | 380 | 3.35994 | 3.86405 | 453 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 200 | 1908.74 | L_Abluft | 380 | 3.35994 | 1.53447 | 433 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 200 | 233.762 | L_Abluft | 400 | 3.53678 | 0.206556 | 420 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 200 | 1185.49 | L_Abluft | 400 | 3.53678 | 1.04752 | 418 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 200 | 233.762 | L_Zuluft | 400 | 3.53678 | 0.206556 | 418 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 200 | 585.492 | L_Zuluft | 400 | 3.53678 | 0.51735 | 416 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 34 | 140 | 394.139 | L_Abluft | 210 | 3.7894 | 0.617887 | 364 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 40 | 140 | 227.046 | L_Zuluft | 210 | 3.7894 | 0.355938 | 216 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 105.202 | L_Zuluft | 130 | 2.9426 | 0.119561 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 397.777 | L_Zuluft | 130 | 2.9426 | 0.45207 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 225.298 | L_Zuluft | 130 | 2.9426 | 0.256049 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 190.955 | L_Zuluft | 130 | 2.9426 | 0.217019 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 154.918 | L_Zuluft | 170 | 3.84801 | 0.288099 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Wickelfalzrohr | EG_Verwaltung_FFB |  | 125 | 190.955 | L_Zuluft | 170 | 3.84801 | 0.355117 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 125 | 190.256 | L_Abluft | 130 | 2.9426 | 0.216224 | 583 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 125 | 171.957 | L_Abluft | 130 | 2.9426 | 0.195427 | 581 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 125 | 257.373 | L_Abluft | 130 | 2.9426 | 0.292502 | 586 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 257.116 | L_Zuluft | 120 | 2.71624 | 0.252502 | 372 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 27 | 125 | 348.976 | L_Zuluft | 120 | 2.71624 | 0.342713 | 370 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 28 | 140 | 299.192 | L_Zuluft | 210 | 3.7894 | 0.46904 | 350 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 106.075 | L_Abluft | 120 | 2.71624 | 0.104171 | 355 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 125 | 965.429 | L_Abluft | 120 | 2.71624 | 0.948102 | 353 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 39 | 140 | 306.701 | L_Zuluft | 210 | 3.7894 | 0.480811 | 245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 47 | 140 | 226.712 | L_Abluft | 210 | 3.7894 | 0.355414 | 255 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 49 | 140 | 255.734 | L_Abluft | 210 | 3.7894 | 0.400911 | 215 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 38 | 100 | 159.583 | L_Zuluft | 40 | 1.41471 | 0.0643408 | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 100 | 159.583 | L_Abluft | 40 | 1.41471 | 0.0643408 | 270 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 159.583 | L_Zuluft | 40 | 1.41471 | 0.0643408 | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 892.073 | L_Zuluft | 40 | 1.41471 | 0.359668 | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 154.667 | L_Zuluft | 40 | 1.41471 | 0.0623588 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 36 | 100 | 88 | L_Zuluft | 40 | 1.41471 | 0.03548 | 298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 100 | 657.927 | L_Abluft | 40 | 1.41471 | 0.265264 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 46 | 100 | 88 | L_Abluft | 40 | 1.41471 | 0.03548 | 277 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 100 | 137.46 | L_Zuluft | 60 | 2.12207 | 0.114546 | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 125 | 131.389 | L_Abluft | 170 | 3.84801 | 0.244344 | 599 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 125 | 121.841 | L_Abluft | 170 | 3.84801 | 0.226586 | 597 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 131.389 | L_Abluft | 170 | 3.84801 | 0.244344 | 614 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 121.841 | L_Abluft | 170 | 3.84801 | 0.226586 | 612 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 125 | 257.813 | L_Abluft | 130 | 2.9426 | 0.293002 | 579 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 125 | 295 | L_Abluft | 130 | 2.9426 | 0.335265 | 577 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 125 | 310 | L_Abluft | 170 | 3.84801 | 0.576503 | 595 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 125 | 320 | L_Abluft | 170 | 3.84801 | 0.5951 | 610 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 21 | 200 | 320 | L_Zuluft | 400 | 3.53678 | 0.282757 | 414 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 30 | 200 | 320 | L_Abluft | 400 | 3.53678 | 0.282757 | 416 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 268.309 | L_Abluft | 440 | 3.89045 | 0.28272 | 52 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 2578.77 | L_Abluft | 440 | 3.89045 | 2.71729 | 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 268.309 | L_Abluft | 440 | 3.89045 | 0.28272 | 67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 6000 | L_Abluft | 440 | 3.89045 | 6.32227 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 4241.42 | L_Abluft | 440 | 3.89045 | 4.46923 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 250 | L_Abluft | 440 | 3.89045 | 0.263428 | 62 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 372.994 | L_Abluft | 440 | 3.89045 | 0.393029 | 75 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 250 | L_Abluft | 440 | 3.89045 | 0.263428 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 32 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 236.546 | L_Zuluft | 440 | 3.89045 | 0.249251 | 17 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 177.816 | L_Zuluft | 440 | 3.89045 | 0.187367 | 20 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 200 | 223.478 | L_Zuluft | 440 | 3.89045 | 0.235481 | 15 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 46 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 14 | 200 | 300 | L_Zuluft | 440 | 3.89045 | 0.316114 | 42 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 60 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 901.165 | L_Zuluft | 440 | 3.89045 | 0.949568 | 58 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 75 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 268.309 | L_Zuluft | 440 | 3.89045 | 0.28272 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 263.205 | L_Abluft | 440 | 3.89045 | 0.277343 | 123 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 263.205 | L_Abluft | 440 | 3.89045 | 0.277343 | 98 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 263.205 | L_Abluft | 440 | 3.89045 | 0.277343 | 139 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 268.309 | L_Abluft | 440 | 3.89045 | 0.28272 | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 200 | 325.721 | L_Zuluft | 440 | 3.89045 | 0.343217 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 200 | 350 | L_Zuluft | 440 | 3.89045 | 0.368799 | 71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 685.994 | L_Zuluft | 440 | 3.89045 | 0.72284 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 350 | L_Zuluft | 440 | 3.89045 | 0.368799 | 97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 350 | L_Zuluft | 440 | 3.89045 | 0.368799 | 86 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 6000 | L_Zuluft | 440 | 3.89045 | 6.32227 | 88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 800.927 | L_Zuluft | 440 | 3.89045 | 0.843946 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 6000 | L_Zuluft | 440 | 3.89045 | 6.32227 | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 836.773 | L_Zuluft | 440 | 3.89045 | 0.881718 | 107 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 350 | L_Zuluft | 440 | 3.89045 | 0.368799 | 109 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 400.721 | L_Zuluft | 440 | 3.89045 | 0.422245 | 111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 6000 | L_Abluft | 440 | 3.89045 | 6.32227 | 96 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 1481.03 | L_Abluft | 440 | 3.89045 | 1.56058 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 200 | 350 | L_Abluft | 440 | 3.89045 | 0.368799 | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 200 | 350 | L_Abluft | 440 | 3.89045 | 0.368799 | 103 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 12 | 200 | 184.305 | L_Abluft | 440 | 3.89045 | 0.194204 | 107 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 950.719 | L_Abluft | 440 | 3.89045 | 1.00178 | 121 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 11 | 200 | 350 | L_Abluft | 440 | 3.89045 | 0.368799 | 119 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 375 | L_Abluft | 440 | 3.89045 | 0.395142 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 9 | 200 | 160.996 | L_Abluft | 440 | 3.89045 | 0.169644 | 147 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 6000 | L_Abluft | 440 | 3.89045 | 6.32227 | 137 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 1331.03 | L_Abluft | 440 | 3.89045 | 1.40252 | 136 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 10 | 200 | 400 | L_Abluft | 440 | 3.89045 | 0.421485 | 134 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 16 | 125 | 134.947 | L_Abluft | 130 | 2.9426 | 0.153366 | 231 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 13 | 160 | 3915.16 | L_Abluft | 280 | 3.86835 | 5.39318 | 238 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | EG_Verwaltung_FFB | 15 | 125 | 335.77 | L_Zuluft | 130 | 2.9426 | 0.3816 | 269 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
