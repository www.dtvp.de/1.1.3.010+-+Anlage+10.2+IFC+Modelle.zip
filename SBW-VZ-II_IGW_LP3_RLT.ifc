Properties of the parts of a building model (IFC2X3), part 12 of 18

# IfcFlowSegment: Luftleitungsteil (469)
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitungsteil | EG_Verwaltung_FFB | 8 | 300 | 200 | 394.172 | 1 | L_Abluft | 1.89203 | 840 | 3.88889 | 0.330922 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 9 | 250 | 200 | 509.34 | 1 | L_Abluft | 2.20035 | 590 | 3.27778 | 0.343128 | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 300 | 250 | 835.051 | 1 | L_Zuluft | 4.40907 | 840 | 3.11111 | 0.39633 | 158 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 16 | 300 | 500 | 783.962 | 1.25434 | L_Abluft | 6.02083 | 1715 | 3.17593 | 0.260878 | 92 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 8 | 200 | 200 | 747.518 | 1 | L_Abluft | 2.87047 | 470 | 3.26389 | 0.569709 | 572 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 25 | 200 | 200 | 700 | 1 | L_Abluft | 2.688 | 490 | 3.40278 | 0.576029 | 102 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 25 | 200 | 200 | 693.335 | 1 | L_Abluft | 2.66241 | 490 | 3.40278 | 0.570544 | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 17 | 300 | 350 | 513.448 | 1 | L_Abluft | 3.20391 | 1225 | 3.24074 | 0.213085 | 129 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 20 | 400 | 400 | 400 | 1 | L_Zuluft | 3.072 | 2015 | 3.49826 | 0.367518 | 568 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 18 | 400 | 450 | 363.089 | 1 | L_Zuluft | 2.9628 | 2450 | 3.78086 | 0.143674 | 450 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 200 | 250 | 800 | 1 | L_Zuluft | 3.456 | 560 | 3.11111 | 0.489608 | 801 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 6 | 350 | 250 | 646.684 | 1 | L_Zuluft | 3.7249 | 995 | 3.15873 | 0.290465 | 790 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 600 | 250 | 700 | 1.19 | L_Abluft | 7.616 | 1935 | 3.58333 | 0.313691 | 810 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 61 | 350 | 200 | 871.241 | 1 | L_Zuluft | 4.60015 | 810 | 3.21429 | 0.478302 | 261 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 71 | 500 | 550 | 709.443 | 1.48983 | L_Zuluft | 9.53491 | 3570 | 3.60606 | 0.198269 | 39 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 400 | 300 | 628.839 | 1 | L_Abluft | 4.2258 | 1590 | 3.68056 | 0.306878 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 600 | 450 | 785.047 | 1.6486 | L_Abluft | 10.551 | 3520 | 3.6214 | 0.226143 | 43 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 2 | 600 | 450 | 785.047 | 1.6486 | L_Zuluft | 10.551 | 3520 | 3.6214 | 0.226143 | 8 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 300 | 600 | 696.906 | 1.25443 | L_Zuluft | 8.02835 | 2200 | 3.39506 | 0.242313 | 54 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 19 | 500 | 400 | 371.383 | 1 | L_Abluft | 3.20875 | 2570 | 3.56944 | 0.124508 | 455 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 600 | 250 | 714.804 | 1.21517 | L_Abluft | 7.77707 | 1935 | 3.58333 | 0.320325 | 809 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 250 | 200 | 542.826 | 1 | L_Zuluft | 2.34501 | 560 | 3.11111 | 0.332215 | 803 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 250 | 200 | 363.943 | 1 | L_Zuluft | 1.57223 | 560 | 3.11111 | 0.222737 | 805 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 400 | 300 | 485.942 | 1 | L_Abluft | 3.26553 | 630 | 1.45833 | 0.0436744 | 842 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 600 | 450 | 500 | 1.05 | L_Zuluft | 6.72 | 3640 | 3.74486 | 0.458918 | 186 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 197 | 400 | 300 | 279.642 | 1 | L_Zuluft | 1.8792 | 885 | 2.04861 | 0.063895 | 332 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 192 | 400 | 300 | 294.935 | 1 | L_Zuluft | 1.98196 | 885 | 2.04861 | 0.0673891 | 345 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 172 | 500 | 700 | 247.536 | 1 | L_Zuluft | 3.80216 | 4720 | 3.74603 | 0.0651186 | 324 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 173 | 500 | 500 | 49.66 | 1 | L_Zuluft | 0.476736 | 2950 | 3.27778 | 0.0123093 | 358 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 16 | 200 | 200 | 614.73 | 1 | L_Abluft | 2.36056 | 431 | 2.99306 | 0.399584 | 475 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 13 | 400 | 350 | 470.27 | 1 | L_Abluft | 3.38595 | 1792 | 3.55556 | 0.193863 | 482 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 700 | 500 | 550 | 1.32 | L_Abluft | 8.448 | 4961 | 3.9373 | 0.158726 | 469 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 13 | 400 | 350 | 320 | 1 | L_Abluft | 2.304 | 1792 | 3.55556 | 0.131916 | 483 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 14 | 200 | 400 | 52.2842 | 1 | L_Abluft | 0.301157 | 896 | 3.11111 | 0.0255156 | 492 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 200 | 200 | 614.73 | 1 | L_Abluft | 2.36056 | 432 | 3 | 0.401287 | 520 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 10 | 200 | 400 | 152.284 | 1 | L_Abluft | 0.877157 | 895 | 3.10764 | 0.0741648 | 506 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 9 | 200 | 400 | 152.284 | 1 | L_Abluft | 0.877157 | 516 | 1.79167 | 0.0271481 | 516 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 75 | 250 | 400 | 476.566 | 1 | L_Abluft | 2.97377 | 1350 | 3.75 | 0.275103 | 105 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 64 | 400 | 200 | 423.97 | 1 | L_Abluft | 2.44207 | 900 | 3.125 | 0.208608 | 177 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 65 | 400 | 200 | 373.97 | 1 | L_Abluft | 2.15407 | 900 | 3.125 | 0.184006 | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 63 | 250 | 550 | 894.101 | 1.43056 | L_Abluft | 9.15559 | 1800 | 3.63636 | 0.425311 | 165 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 67 | 400 | 200 | 423.97 | 1 | L_Abluft | 2.44207 | 900 | 3.125 | 0.208608 | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 56 | 250 | 400 | 146.274 | 1 | L_Abluft | 0.912752 | 1350 | 3.75 | 0.0844386 | 224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 46 | 400 | 200 | 423.97 | 1 | L_Abluft | 2.44207 | 1100 | 3.81944 | 0.302148 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 45 | 400 | 200 | 423.97 | 1 | L_Abluft | 2.44207 | 1100 | 3.81944 | 0.302148 | 304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 45 | 400 | 200 | 133.506 | 1 | L_Abluft | 0.768994 | 1100 | 3.81944 | 0.0951448 | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 39 | 400 | 200 | 373.97 | 1 | L_Abluft | 2.15407 | 1125 | 3.90625 | 0.277845 | 341 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 10 | 200 | 200 | 729.254 | 1 | L_Abluft | 2.80034 | 490 | 3.40278 | 0.600102 | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 300 | 500 | 603.97 | 1 | L_Abluft | 4.63849 | 1340 | 2.48148 | 0.127683 | 199 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 400 | 250 | 669.767 | 1 | L_Zuluft | 4.17934 | 1340 | 3.72222 | 0.381344 | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 200 | 200 | 400 | 1 | L_Zuluft | 1.536 | 500 | 3.47222 | 0.341644 | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 16 | 350 | 250 | 800 | 1 | L_Zuluft | 4.608 | 1225 | 3.88889 | 0.52771 | 76 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 24 | 200 | 200 | 138.498 | 1 | L_Zuluft | 0.531833 | 490 | 3.40278 | 0.11397 | 48 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 8 | 300 | 200 | 193.934 | 1 | L_Abluft | 0.930883 | 840 | 3.88889 | 0.162814 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 8 | 300 | 200 | 834.315 | 1 | L_Abluft | 4.00471 | 840 | 3.88889 | 0.700437 | 205 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 25 | 200 | 200 | 103.143 | 1 | L_Abluft | 0.396069 | 490 | 3.40278 | 0.0848762 | 95 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 12 | 200 | 200 | 549.25 | 1 | L_Zuluft | 2.10912 | 460 | 3.19444 | 0.402371 | 247 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 12 | 200 | 200 | 688.721 | 1 | L_Zuluft | 2.64469 | 460 | 3.19444 | 0.504545 | 244 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 300 | 350 | 641.123 | 1 | L_Zuluft | 4.00061 | 1210 | 3.20106 | 0.260094 | 241 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 61 | 650 | 500 | 550 | 1.265 | L_Abluft | 8.096 | 4380 | 3.74359 | 0.150168 | 58 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 60 | 650 | 500 | 550 | 1.265 | L_Zuluft | 8.096 | 4380 | 3.74359 | 0.150168 | 34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 7 | 250 | 200 | 200 | 1 | L_Abluft | 0.864 | 630 | 3.5 | 0.152048 | 844 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 17 | 300 | 600 | 853.283 | 1.53591 | L_Zuluft | 9.82982 | 2570 | 3.96605 | 0.395778 | 432 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 13 | 400 | 600 | 793.036 | 1.58607 | L_Abluft | 10.1509 | 3190 | 3.69213 | 0.257622 | 191 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 15 | 500 | 300 | 774 | 1.2384 | L_Abluft | 5.94432 | 1900 | 3.51852 | 0.391697 | 389 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 500 | 350 | 854 | 1.4518 | L_Zuluft | 6.96864 | 2220 | 3.52381 | 0.378856 | 383 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 450 | 600 | 615.642 | 1.29285 | L_Zuluft | 8.27423 | 3190 | 3.28189 | 0.147776 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 13 | 600 | 400 | 300 | 1 | L_Abluft | 3.84 | 3190 | 3.69213 | 0.415257 | 189 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 600 | 450 | 657 | 1.3797 | L_Zuluft | 8.83008 | 3190 | 3.28189 | 0.157704 | 199 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 512.132 | 1 | L_Zuluft | 1.96659 |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 733.414 | 1 | L_Zuluft | 2.81631 |  |  |  |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 650 | 350 | 569.895 | 1.13979 | L_Zuluft | 7.29466 | 2220 | 2.71062 | 0.111691 | 379 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 4 | 650 | 350 | 750 | 1.5 | L_Zuluft | 9.6 | 3190 | 3.89499 | 0.344439 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 25 | 300 | 200 | 601.277 | 1 | L_Zuluft | 2.88613 | 760 | 3.51852 | 0.419516 | 228 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 24 | 350 | 200 | 417.789 | 1 | L_Zuluft | 2.20593 | 970 | 3.84921 | 0.319954 | 206 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 300 | 200 | 540.406 | 1 | L_Abluft | 2.59395 | 750 | 3.47222 | 0.367941 | 268 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 5 | 300 | 200 | 641.316 | 1 | L_Abluft | 3.07832 | 750 | 3.47222 | 0.436646 | 270 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 6 | 300 | 200 | 370.977 | 1 | L_Zuluft | 1.78069 | 750 | 3.47222 | 0.252583 | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 6 | 300 | 200 | 862.344 | 1 | L_Zuluft | 4.13925 | 750 | 3.47222 | 0.587135 | 321 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 6 | 300 | 200 | 223.293 | 1 | L_Zuluft | 1.0718 | 750 | 3.47222 | 0.152031 | 320 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 500 | 400 | 550.007 | 1 | L_Zuluft | 4.75206 | 2530 | 3.51389 | 0.17911 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 21 | 200 | 300 | 672.687 | 1 | L_Zuluft | 3.2289 | 780 | 3.61111 | 0.492403 | 109 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 2 | 400 | 500 | 550.007 | 1 | L_Abluft | 4.75206 | 2590 | 3.59722 | 0.187061 | 33 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 19 | 200 | 200 | 244.564 | 1 | L_Abluft | 0.939127 | 490 | 3.40278 | 0.201252 | 168 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 18 | 200 | 200 | 595.516 | 1 | L_Zuluft | 2.28678 | 490 | 3.40278 | 0.490049 | 124 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 15 | 300 | 500 | 712.436 | 1.1399 | L_Abluft | 5.47151 | 1960 | 3.62963 | 0.303457 | 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 15 | 300 | 500 | 346.41 | 1 | L_Abluft | 2.66043 | 1960 | 3.62963 | 0.147551 | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 400 | 152.284 | 1 | L_Abluft | 0.877157 | 432 | 1.5 | 0.0196978
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 400 | 152.284 | 1 | L_Abluft | 0.877157 | 431 | 1.49653 | 0.0196158
Luftleitungsteil | EG_Verwaltung_FFB |  | 700 | 400 | 275.358 | 1 | L_Abluft | 3.87705 | 2223 | 2.20536 | 0.0322044
2 x Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 125.897 | 1 | L_Abluft | 0.483444 | 895 | 6.21528 | 0.317707
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 400 | 152.284 | 1 | L_Abluft | 0.877157 | 895 | 3.10764 | 0.0741648
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 673.838 | 1 | L_Abluft | 2.58754 | 516 | 3.58333 | 0.609952
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 715.897 | 1 | L_Abluft | 2.74904 | 516 | 3.58333 | 0.648024
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 450 | 785.501 | 1.33535 | L_Zuluft | 6.40969
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 300 | 350 | 1 | L_Zuluft | 2.688
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 350 | 842.97 | 1.43305 | L_Zuluft | 6.87864 | 2202 | 3.49524 | 0.298514
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 373.97 | 1 | L_Abluft | 2.15407 | 1000 | 3.47222 | 0.223451
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 500 | 570.067 | 1 | L_Abluft | 4.37812 | 2000 | 3.7037 | 0.252078
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 250 | 134.437 | 1 | L_Abluft | 0.838885 | 1000 | 2.77778 | 0.0446231
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 423.97 | 1 | L_Abluft | 2.44207 | 1000 | 3.47222 | 0.253326
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 250 | 143.977 | 1 | L_Abluft | 0.898417 | 1000 | 2.77778 | 0.0477899
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 323.97 | 1 | L_Abluft | 1.86607 | 1350 | 4.6875 | 0.337781
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 400 | 458.062 | 1 | L_Abluft | 3.07817 | 1350 | 3.125 | 0.165215
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 250 | 727.162 | 1 | L_Abluft | 4.53749 | 1350 | 3.75 | 0.419763
Luftleitungsteil | EG_Verwaltung_FFB |  | 650 | 300 | 673.434 | 1.27952 | L_Abluft | 8.18896 | 2700 | 3.84615 | 0.2858
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 350 | 327.162 | 1 | L_Abluft | 2.35556 | 1350 | 2.67857 | 0.0800088
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 248.97 | 1 | L_Abluft | 1.43407 | 1350 | 4.6875 | 0.259584
2 x Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 298.97 | 1 | L_Abluft | 1.72207 | 1350 | 4.6875 | 0.311716
Luftleitungsteil | EG_Verwaltung_FFB |  | 800 | 350 | 100 | 1 | L_Abluft | 1.472 | 4050 | 4.01786 | 0.0373488
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 300 | 648 | 1.0368 | L_Abluft | 4.97664 | 1800 | 3.33333 | 0.23578
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 400 | 319.011 | 1 | L_Abluft | 1.8375 | 900 | 3.125 | 0.156964
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 400 | 199.911 | 1 | L_Abluft | 1.3434 | 900 | 2.08333 | 0.0342986
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 400 | 200.411 | 1 | L_Abluft | 1.34676 | 900 | 2.08333 | 0.0343844
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 400 | 319.511 | 1 | L_Abluft | 1.84038 | 900 | 3.125 | 0.15721
Luftleitungsteil | EG_Verwaltung_FFB |  | 250 | 400 | 71.2744 | 1 | L_Abluft | 0.444752 | 1350 | 3.75 | 0.041144
Luftleitungsteil | EG_Verwaltung_FFB |  | 650 | 300 | 774.295 | 1.47116 | L_Abluft | 9.41542 | 2700 | 3.84615 | 0.328605
Luftleitungsteil | EG_Verwaltung_FFB |  | 250 | 400 | 349.603 | 1 | L_Abluft | 2.18152 | 1350 | 3.75 | 0.201813
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 400 | 99.6032 | 1 | L_Abluft | 0.669333 | 1350 | 3.125 | 0.0359251
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 650 | 644.381 | 1.22432 | L_Abluft | 7.83568 | 2700 | 3.84615 | 0.27347
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 400 | 228.941 | 1 | L_Abluft | 1.3187 | 1100 | 3.81944 | 0.163158
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 228.941 | 1 | L_Abluft | 1.3187 | 1100 | 3.81944 | 0.163158
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 550 | 548.003 | 1 | L_Abluft | 5.96227 | 2250 | 3.78788 | 0.242104
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 400 | 601.363 | 1 | L_Abluft | 4.04116 | 1125 | 2.60417 | 0.155126
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 373.97 | 1 | L_Abluft | 2.15407 | 1125 | 3.90625 | 0.277845
2 x Luftleitungsteil | EG_Verwaltung_FFB |  | 450 | 450 | 436.868 | 1 | L_Zuluft | 3.77454 | 1802 | 2.47188 | 0.0732713
Luftleitungsteil | EG_Verwaltung_FFB |  | 450 | 800 | 163.416 | 1 | L_Zuluft | 2.61466 | 5047 | 3.89429 | 0.046924
Luftleitungsteil | EG_Verwaltung_FFB |  | 450 | 800 | 166.645 | 1 | L_Zuluft | 2.66632 | 5047 | 3.89429 | 0.0478513
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 350 | 336.443 | 1 | L_Zuluft | 2.09941 | 1442 | 3.81481 | 0.188778
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 350 | 355.636 | 1 | L_Zuluft | 2.21917 | 1442 | 3.81481 | 0.199547
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 800 | 144.608 | 1 | L_Zuluft | 2.40628 | 5768 | 4.00556 | 0.0403747
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 450 | 279.746 | 1 | L_Zuluft | 2.55129 | 2524 | 3.11605 | 0.0674701
Luftleitungsteil | EG_Verwaltung_FFB |  | 450 | 350 | 263.284 | 1 | L_Zuluft | 2.02202 | 2163 | 3.81481 | 0.115831
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 450 | 100.315 | 1 | L_Zuluft | 0.770418 | 2163 | 3.81481 | 0.044133
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 400 | 603.284 | 1.08591 | L_Zuluft | 5.21237 | 2523 | 3.50417 | 0.195454
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 300 | 543.715 | 1 | L_Abluft | 4.17573 | 1800 | 3.33333 | 0.197835
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 300 | 653.285 | 1.04526 | L_Abluft | 5.01723 | 1800 | 3.33333 | 0.237703
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 300 | 382.717 | 1 | L_Abluft | 2.38815 | 1350 | 3.57143 | 0.190063
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 350 | 680.52 | 1 | L_Zuluft | 4.24644 | 1350 | 3.57143 | 0.337957
3 x Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 350 | 326.623 | 1 | L_Abluft | 2.03812 | 1350 | 3.57143 | 0.162206
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 300 | 610.937 | 1 | L_Abluft | 3.81225 | 1350 | 3.57143 | 0.303401
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 350 | 386.746 | 1 | L_Abluft | 2.4133 | 1350 | 3.57143 | 0.192064
Luftleitungsteil | EG_Verwaltung_FFB |  | 250 | 300 | 359.884 | 1 | L_Zuluft | 1.90019
Luftleitungsteil | EG_Verwaltung_FFB |  | 250 | 300 | 356.884 | 1 | L_Zuluft | 1.88435
Luftleitungsteil | EG_Verwaltung_FFB |  | 250 | 200 | 342.871 | 1 | L_Zuluft | 1.4812
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 500 | 300 | 1 | L_Zuluft | 2.448
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 200 | 485.347 | 1 | L_Abluft | 2.32967
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 200 | 385.803 | 1 | L_Abluft | 1.85185
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 500 | 559.1 | 1 | L_Zuluft | 4.56226
Luftleitungsteil | EG_Verwaltung_FFB |  | 250 | 400 | 171.331 | 1 | L_Abluft | 1.0691
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 650 | 476.887 | 1 | L_Abluft | 5.79895
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 500 | 317.432 | 1 | L_Zuluft | 2.13314
Luftleitungsteil | EG_Verwaltung_FFB |  | 450 | 600 | 371.706 | 1 | L_Zuluft | 4.99573
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 600 | 813.312 | 1.46396 | L_Zuluft | 9.36935
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 450 | 350 | 1 | L_Zuluft | 2.688
Luftleitungsteil | EG_Verwaltung_FFB | 3 | 600 | 450 | 300 | 1 | L_Zuluft | 4.032 | 3640 | 3.74486 | 0.458918 | 186 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 829.678 | 1 | L_Abluft | 3.18596
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 200 | 323.086 | 1 | L_Zuluft | 1.55081
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 700 | 1 | L_Zuluft | 4.032
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 250 | 699.421 | 1 | L_Zuluft | 3.69294
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 400 | 551.363 | 1 | L_Abluft | 3.70516
Luftleitungsteil | EG_Verwaltung_FFB |  | 300 | 200 | 737.607 | 1 | L_Zuluft | 3.54051
Luftleitungsteil | EG_Verwaltung_FFB | 21 | 400 | 200 | 500 | 1 | L_Abluft | 2.88 | 1000 | 3.47222 | 0.896263 | 41 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB | 20 | 400 | 200 | 500 | 1 | L_Zuluft | 2.88 | 1000 | 3.47222 | 0.896263 | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 300 | 405.92 | 1 | L_Abluft | 3.11747
3 x Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 323.97 | 1 | L_Abluft | 1.86607
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 298.97 | 1 | L_Abluft | 1.72207
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 273.97 | 1 | L_Abluft | 1.57807
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 348.97 | 1 | L_Abluft | 2.01007
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 200 | 150 | 1 | L_Abluft | 0.864
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 300 | 413.729 | 1 | L_Abluft | 1.9859
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 300 | 774.366 | 1 | L_Abluft | 3.71696
2 x Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 300 | 413.729 | 1 | L_Zuluft | 1.9859
2 x Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 300 | 774.366 | 1 | L_Zuluft | 3.71696
Luftleitungsteil | EG_Verwaltung_FFB |  | 200 | 200 | 426.894 | 1 | L_Abluft | 1.63927
Luftleitungsteil | EG_Verwaltung_FFB |  | 350 | 500 | 511.612 | 1 | L_Abluft | 4.17475
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 200 | 715.047 | 1.00107 | L_Abluft | 4.80512
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 200 | 536.663 | 1 | L_Abluft | 3.60638
Luftleitungsteil | EG_Verwaltung_FFB |  | 500 | 200 | 715.047 | 1.00107 | L_Zuluft | 4.80512
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 350 | 517.764 | 1 | L_Abluft | 3.7279
Luftleitungsteil | EG_Verwaltung_FFB |  | 400 | 400 | 760.618 | 1.21699 | L_Zuluft | 5.84155

# IfcFlowSegment: Muffe (257)
Description: Muffe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Muffe; Abbreviation: MFA
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Half length (mm) (mm) | Geom-Additional length (mm) (mm) | Tech-Medium | Pos. No. | Floor | Floor No. | Building = Building No.
Muffe | Wartung_FFB | 1 | 450 | 80 | 20 | L_Abluft | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 1 | 400 | 80 | 20 | L_Abluft | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 85 | 250 | 60 | 15 | L_Zuluft | 477 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 119 | 250 | 60 | 15 | L_Zuluft | 298 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 50 | 250 | 60 | 15 | L_Zuluft | 187 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 133 | 630 | 80 | 20 | L_Zuluft | 196 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 57 | 160 | 40 | 15 | L_Zuluft | 124 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 59 | 160 | 40 | 15 | L_Zuluft | 109 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 61 | 160 | 40 | 15 | L_Zuluft | 95 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 63 | 160 | 40 | 15 | L_Zuluft | 80 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 23 | 250 | 60 | 15 | L_Zuluft | 338 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 23 | 160 | 40 | 15 | L_Zuluft | 343 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 25 | 160 | 40 | 15 | L_Zuluft | 332 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 138 | 160 | 40 | 15 | L_Zuluft | 142 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 104 | 160 | 40 | 15 | L_Zuluft | 321 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 102 | 160 | 40 | 15 | L_Zuluft | 336 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 100 | 160 | 40 | 15 | L_Zuluft | 350 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 98 | 160 | 40 | 15 | L_Zuluft | 367 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 96 | 160 | 40 | 15 | L_Zuluft | 381 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 94 | 160 | 40 | 15 | L_Zuluft | 396 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 92 | 160 | 40 | 15 | L_Zuluft | 411 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 51 | 140 | 40 | 15 | L_Abluft | 153 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 50 | 100 | 40 | 15 | L_Zuluft | 83 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 55 | 100 | 40 | 15 | L_Abluft | 113 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 50 | 100 | 40 | 15 | L_Zuluft | 88 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 55 | 100 | 40 | 15 | L_Abluft | 115 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 55 | 140 | 40 | 15 | L_Abluft | 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 50 | 140 | 40 | 15 | L_Zuluft | 71 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 49 | 180 | 40 | 15 | L_Zuluft | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 54 | 180 | 40 | 15 | L_Abluft | 73 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 140 | 160 | 40 | 15 | L_Zuluft | 128 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 133 | 630 | 80 | 20 | L_Zuluft | 194 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 65 | 160 | 40 | 15 | L_Zuluft | 61 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 67 | 160 | 40 | 15 | L_Zuluft | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 44 | 250 | 60 | 15 | L_Zuluft | 152 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 50 | 100 | 40 | 15 | L_Zuluft | 90 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | Wartung_FFB | 1 | 560 | 80 | 20 | L_Abluft | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 38 | 100 | 40 | 15 | L_Zuluft | 626 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 53 | 125 | 40 | 15 | L_Zuluft | 443 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 53 | 125 | 40 | 15 | L_Zuluft | 445 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 47 | 100 | 40 | 15 | L_Zuluft | 555 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 48 | 100 | 40 | 15 | L_Abluft | 611 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 32 | 125 | 40 | 15 | L_Zuluft | 726 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 32 | 125 | 40 | 15 | L_Zuluft | 732 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 33 | 125 | 40 | 15 | L_Abluft | 780 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 34 | 140 | 40 | 15 | L_Zuluft | 699 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 34 | 140 | 40 | 15 | L_Zuluft | 701 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 31 | 140 | 40 | 15 | L_Zuluft | 745 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 31 | 140 | 40 | 15 | L_Zuluft | 747 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 29 | 200 | 40 | 15 | L_Zuluft | 736 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 30 | 200 | 40 | 15 | L_Zuluft | 751 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 48 | 100 | 40 | 15 | L_Zuluft | 535 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 36 | 125 | 40 | 15 | L_Zuluft | 664 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 42 | 160 | 40 | 15 | L_Abluft | 640 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 42 | 160 | 40 | 15 | L_Abluft | 648 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 41 | 160 | 40 | 15 | L_Abluft | 661 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 41 | 160 | 40 | 15 | L_Abluft | 669 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 36 | 125 | 40 | 15 | L_Zuluft | 659 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 32 | 200 | 40 | 15 | L_Abluft | 790 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 46 | 160 | 40 | 15 | L_Zuluft | 525 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 47 | 125 | 40 | 15 | L_Zuluft | 545 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 43 | 125 | 40 | 15 | L_Abluft | 629 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 43 | 125 | 40 | 15 | L_Abluft | 631 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 11 | 140 | 40 | 15 | L_Abluft | 887 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 180 | 40 | 15 | L_Abluft | 899 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 180 | 40 | 15 | L_Zuluft | 855 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 11 | 140 | 40 | 15 | L_Abluft | 895 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 88 | 125 | 40 | 15 | L_Abluft | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 91 | 100 | 40 | 15 | L_Abluft | 109 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 90 | 125 | 40 | 15 | L_Abluft | 119 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 91 | 100 | 40 | 15 | L_Abluft | 105 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 68 | 100 | 40 | 15 | L_Zuluft | 301 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 68 | 100 | 40 | 15 | L_Zuluft | 307 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 67 | 100 | 40 | 15 | L_Zuluft | 326 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 87 | 180 | 40 | 15 | L_Abluft | 153 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 67 | 125 | 40 | 15 | L_Zuluft | 313 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 64 | 180 | 40 | 15 | L_Zuluft | 293 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 65 | 180 | 40 | 15 | L_Zuluft | 332 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 66 | 180 | 40 | 15 | L_Zuluft | 295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 63 | 180 | 40 | 15 | L_Zuluft | 343 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 85 | 180 | 40 | 15 | L_Zuluft | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 76 | 180 | 40 | 15 | L_Abluft | 285 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 80 | 125 | 40 | 15 | L_Abluft | 225 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 87 | 140 | 40 | 15 | L_Zuluft | 130 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 78 | 140 | 40 | 15 | L_Abluft | 256 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 75 | 160 | 40 | 15 | L_Abluft | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 84 | 160 | 40 | 15 | L_Zuluft | 174 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 73 | 125 | 40 | 15 | L_Abluft | 336 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 83 | 125 | 40 | 15 | L_Zuluft | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 76 | 180 | 40 | 15 | L_Abluft | 291 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 85 | 180 | 40 | 15 | L_Zuluft | 165 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 82 | 160 | 40 | 15 | L_Zuluft | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 74 | 160 | 40 | 15 | L_Abluft | 322 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 72 | 200 | 40 | 15 | L_Abluft | 348 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 86 | 140 | 40 | 15 | L_Zuluft | 139 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 86 | 140 | 40 | 15 | L_Zuluft | 144 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 77 | 140 | 40 | 15 | L_Abluft | 265 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 77 | 140 | 40 | 15 | L_Abluft | 270 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 88 | 140 | 40 | 15 | L_Zuluft | 108 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 88 | 140 | 40 | 15 | L_Zuluft | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 79 | 140 | 40 | 15 | L_Abluft | 234 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 79 | 140 | 40 | 15 | L_Abluft | 239 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 89 | 125 | 40 | 15 | L_Zuluft | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 81 | 125 | 40 | 15 | L_Abluft | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 90 | 125 | 40 | 15 | L_Zuluft | 74 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 125 | 40 | 15 | L_Zuluft | 857 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 9 | 200 | 40 | 15 | L_Zuluft | 840 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 9 | 200 | 40 | 15 | L_Abluft | 879 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 58 | 200 | 40 | 15 | L_Abluft | 433 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 35 | 125 | 40 | 15 | L_Abluft | 754 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 48 | 125 | 40 | 15 | L_Abluft | 597 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 49 | 100 | 40 | 15 | L_Abluft | 591 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 47 | 140 | 40 | 15 | L_Abluft | 585 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 46 | 160 | 40 | 15 | L_Abluft | 563 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 45 | 180 | 40 | 15 | L_Abluft | 543 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 44 | 180 | 40 | 15 | L_Zuluft | 485 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 12 | 200 | 40 | 15 | L_Zuluft | 553 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 24 | 140 | 40 | 15 | L_Abluft | 531 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 23 | 140 | 40 | 15 | L_Abluft | 547 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 22 | 200 | 40 | 15 | L_Abluft | 554 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 25 | 140 | 40 | 15 | L_Abluft | 498 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 26 | 140 | 40 | 15 | L_Abluft | 479 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 15 | 140 | 40 | 15 | L_Zuluft | 500 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 20 | 140 | 40 | 15 | L_Zuluft | 445 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 29 | 140 | 40 | 15 | L_Abluft | 440 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 19 | 140 | 40 | 15 | L_Zuluft | 460 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 18 | 140 | 40 | 15 | L_Zuluft | 483 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 28 | 140 | 40 | 15 | L_Abluft | 464 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 18 | 200 | 40 | 15 | L_Zuluft | 467 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 28 | 200 | 40 | 15 | L_Abluft | 447 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Muffe | EG_Verwaltung_FFB |  | 125 | 40 | 15 | L_Zuluft |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB |  | 180 | 40 | 15 | L_Zuluft |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 125 | 40 | 15 | L_Abluft | 617 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 180 | 40 | 15 | L_Abluft | 606 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 11 | 125 | 40 | 15 | L_Abluft | 602 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 12 | 125 | 40 | 15 | L_Abluft | 588 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 37 | 125 | 40 | 15 | L_Abluft | 350 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 37 | 125 | 40 | 15 | L_Abluft | 357 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 48 | 100 | 40 | 15 | L_Abluft | 240 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 46 | 100 | 40 | 15 | L_Abluft | 273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 12 | 200 | 40 | 15 | L_Abluft | 105 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 13 | 180 | 40 | 15 | L_Abluft | 236 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 16 | 125 | 40 | 15 | L_Abluft | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 16 | 125 | 40 | 15 | L_Abluft | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 14 | 180 | 40 | 15 | L_Zuluft | 278 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 15 | 125 | 40 | 15 | L_Zuluft | 271 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 16 | 125 | 40 | 15 | L_Zuluft | 258 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 16 | 125 | 40 | 15 | L_Zuluft | 260 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 18 | 180 | 40 | 15 | L_Zuluft | 207 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 19 | 180 | 40 | 15 | L_Abluft | 170 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 18 | 125 | 40 | 15 | L_Zuluft | 224 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 19 | 125 | 40 | 15 | L_Abluft | 187 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 14 | 160 | 40 | 15 | L_Abluft | 257 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 9 | 180 | 40 | 15 | L_Zuluft | 365 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 7 | 180 | 40 | 15 | L_Abluft | 355 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 100 | 40 | 15 | L_Abluft | 314 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 9 | 100 | 40 | 15 | L_Abluft | 331 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 25 | 160 | 40 | 15 | L_Abluft | 85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 25 | 100 | 40 | 15 | L_Zuluft | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 27 | 100 | 40 | 15 | L_Abluft | 97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 29 | 160 | 40 | 15 | L_Abluft | 61 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 26 | 160 | 40 | 15 | L_Abluft | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 26 | 125 | 40 | 15 | L_Abluft | 115 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 24 | 160 | 40 | 15 | L_Zuluft | 163 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 24 | 125 | 40 | 15 | L_Zuluft | 177 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 26 | 160 | 40 | 15 | L_Zuluft | 136 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 27 | 160 | 40 | 15 | L_Zuluft | 116 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 22 | 160 | 40 | 15 | L_Abluft | 136 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 22 | 160 | 40 | 15 | L_Abluft | 138 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 5 | 160 | 40 | 15 | L_Zuluft | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 11 | 160 | 40 | 15 | L_Abluft | 269 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 6 | 160 | 40 | 15 | L_Abluft | 298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 12 | 160 | 40 | 15 | L_Zuluft | 189 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 12 | 160 | 40 | 15 | L_Zuluft | 191 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 14 | 160 | 40 | 15 | L_Abluft | 218 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 13 | 100 | 40 | 15 | L_Zuluft | 171 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 43 | 100 | 40 | 15 | L_Abluft | 323 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 30 | 200 | 40 | 15 | L_Zuluft | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 31 | 200 | 40 | 15 | L_Zuluft | 267 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 33 | 160 | 40 | 15 | L_Zuluft | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 40 | 200 | 40 | 15 | L_Abluft | 260 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 42 | 125 | 40 | 15 | L_Abluft | 293 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 27 | 180 | 40 | 15 | L_Zuluft | 355 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 26 | 160 | 40 | 15 | L_Zuluft | 56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 27 | 160 | 40 | 15 | L_Abluft | 106 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 28 | 160 | 40 | 15 | L_Abluft | 84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 22 | 160 | 40 | 15 | L_Abluft | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 13 | 140 | 40 | 15 | L_Zuluft | 542 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 87 | 100 | 40 | 15 | L_Abluft | 163 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 83 | 160 | 40 | 15 | L_Abluft | 179 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 92 | 160 | 40 | 15 | L_Abluft | 87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 125 | 40 | 15 | L_Zuluft | 868 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 32 | 125 | 40 | 15 | L_Abluft | 802 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 53 | 100 | 40 | 15 | L_Abluft | 510 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 52 | 100 | 40 | 15 | L_Zuluft | 460 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 55 | 100 | 40 | 15 | L_Abluft | 478 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 55 | 100 | 40 | 15 | L_Abluft | 476 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 169 | 250 | 60 | 15 | L_Zuluft | 109 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 41 | 200 | 40 | 15 | L_Zuluft | 191 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 31 | 125 | 40 | 15 | L_Abluft | 402 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 22 | 125 | 40 | 15 | L_Zuluft | 403 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 2 | 630 | 80 | 20 | L_Abluft | 14 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 9 | 100 | 40 | 15 | L_Abluft | 322 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 9 | 100 | 40 | 15 | L_Abluft | 324 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 10 | 100 | 40 | 15 | L_Abluft | 307 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 11 | 140 | 40 | 15 | L_Zuluft | 851 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 51 | 125 | 40 | 15 | L_Zuluft | 478 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 50 | 100 | 40 | 15 | L_Zuluft | 493 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 50 | 100 | 40 | 15 | L_Zuluft | 495 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 50 | 100 | 40 | 15 | L_Zuluft | 500 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 52 | 100 | 40 | 15 | L_Abluft | 531 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 52 | 100 | 40 | 15 | L_Abluft | 533 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 37 | 125 | 40 | 15 | L_Abluft | 340 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 25 | 100 | 40 | 15 | L_Zuluft | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 20 | 160 | 40 | 15 | L_Abluft | 192 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 21 | 160 | 40 | 15 | L_Abluft | 186 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 26 | 180 | 40 | 15 | L_Zuluft | 336 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 48 | 100 | 40 | 15 | L_Abluft | 231 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 51 | 100 | 40 | 15 | L_Abluft | 547 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 51 | 100 | 40 | 15 | L_Abluft | 553 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 49 | 100 | 40 | 15 | L_Zuluft | 508 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 49 | 100 | 40 | 15 | L_Zuluft | 514 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 50 | 100 | 40 | 15 | L_Abluft | 567 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 6 | 630 | 80 | 20 | L_Abluft | 14 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 6 | 450 | 80 | 20 | L_Abluft | 16 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 4 | 630 | 80 | 20 | L_Abluft | 32 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Muffe | EG_Verwaltung_FFB | 4 | 450 | 80 | 20 | L_Abluft | 34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
16 x Muffe | EG_Verwaltung_FFB |  | 280 | 60 | 15 | L_Zuluft
2 x Muffe | EG_Verwaltung_FFB |  | 200 | 40 | 15 | L_Zuluft
2 x Muffe | EG_Verwaltung_FFB |  | 250 | 60 | 15 | L_Zuluft
2 x Muffe | EG_Verwaltung_FFB |  | 280 | 60 | 15 | L_Abluft
Muffe | EG_Verwaltung_FFB |  | 125 | 40 | 15 | L_Zuluft
2 x Muffe | EG_Verwaltung_FFB |  | 100 | 40 | 15 | L_Abluft
Muffe | EG_Verwaltung_FFB |  | 200 | 40 | 15 | L_Abluft
Muffe | EG_Verwaltung_FFB |  | 100 | 40 | 15 | L_Zuluft
Muffe | EG_Verwaltung_FFB |  | 140 | 40 | 15 | L_Abluft
Muffe | EG_Verwaltung_FFB |  | 140 | 40 | 15 | L_Zuluft

# IfcFlowSegment: Stutzen rund (240)
Description: Stutzen rund
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 50 mm; Tech-Material (ID): 1; Name: Stutzen rund; Abbreviation: SR
Name | In | Section No | Geom-Diameter (mm) (mm) | Tech-Medium | Pos. No. | Floor | Floor No. | Building = Building No.
Stutzen rund | Wartung_FFB | 42 | 250 | L_Zuluft | 93 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 48 | 180 | L_Zuluft | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 53 | 180 | L_Abluft | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 50 | 140 | L_Abluft | 125 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 87 | 160 | L_Zuluft | 464 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 88 | 160 | L_Zuluft | 451 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 89 | 160 | L_Zuluft | 433 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 92 | 160 | L_Zuluft | 407 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 94 | 160 | L_Zuluft | 392 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 96 | 160 | L_Zuluft | 377 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 98 | 160 | L_Zuluft | 363 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 100 | 160 | L_Zuluft | 346 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 102 | 160 | L_Zuluft | 332 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 104 | 160 | L_Zuluft | 317 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 123 | 160 | L_Zuluft | 270 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 125 | 160 | L_Zuluft | 253 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 127 | 160 | L_Zuluft | 238 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 129 | 160 | L_Zuluft | 220 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 131 | 160 | L_Zuluft | 205 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 138 | 160 | L_Zuluft | 138 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 134 | 160 | L_Zuluft | 172 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 142 | 160 | L_Zuluft | 111 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 143 | 160 | L_Zuluft | 97 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 136 | 160 | L_Zuluft | 157 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 52 | 160 | L_Zuluft | 174 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 53 | 160 | L_Zuluft | 163 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 54 | 160 | L_Zuluft | 146 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 57 | 160 | L_Zuluft | 120 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 59 | 160 | L_Zuluft | 105 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 61 | 160 | L_Zuluft | 91 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 27 | 160 | L_Zuluft | 321 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 28 | 160 | L_Zuluft | 309 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 29 | 160 | L_Zuluft | 291 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 30 | 160 | L_Zuluft | 276 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 32 | 160 | L_Zuluft | 257 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 33 | 160 | L_Zuluft | 248 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 34 | 160 | L_Zuluft | 235 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 35 | 160 | L_Zuluft | 226 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 36 | 160 | L_Zuluft | 217 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 37 | 160 | L_Zuluft | 208 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 69 | 160 | L_Zuluft | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 140 | 160 | L_Zuluft | 124 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 67 | 160 | L_Zuluft | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 65 | 160 | L_Zuluft | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | Wartung_FFB | 63 | 160 | L_Zuluft | 76 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 36 | 125 | L_Zuluft | 654 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
