Properties of the parts of a building model (IFC2X3), part 10 of 18

# IfcFlowSegment: Luftleitung (1382)
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitung | EG_Verwaltung_FFB | 75 | 400 | 450 | 1500 | 2.55 | L_Zuluft | 12.24 | 2270 | 3.50309 | 0.515257 | 152 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 75 | 400 | 450 | 1500 | 2.55 | L_Zuluft | 12.24 | 2270 | 3.50309 | 0.515257 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 66 | 400 | 450 | 1500 | 2.55 | L_Abluft | 12.24 | 2270 | 3.50309 | 0.515257 | 278 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 66 | 400 | 450 | 1500 | 2.55 | L_Abluft | 12.24 | 2270 | 3.50309 | 0.515257 | 277 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 74 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2640 | 3.66667 | 0.52857 | 120 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 65 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2640 | 3.66667 | 0.52857 | 246 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 75 | 400 | 450 | 1000 | 1.7 | L_Zuluft | 8.16 | 2270 | 3.50309 | 0.343505 | 150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 66 | 400 | 450 | 1000 | 1.7 | L_Abluft | 8.16 | 2270 | 3.50309 | 0.343505 | 276 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 74 | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96 | 2640 | 3.66667 | 0.52857 | 119 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 65 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2640 | 3.66667 | 0.52857 | 245 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 73 | 400 | 550 | 1500 | 2.85 | L_Zuluft | 18.24 | 2940 | 3.71212 | 0.514168 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 64 | 400 | 550 | 1500 | 2.85 | L_Abluft | 18.24 | 2940 | 3.71212 | 0.514168 | 214 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 74 | 400 | 500 | 1129.44 | 2.03299 | L_Zuluft | 9.75833 | 2640 | 3.66667 | 0.397991 | 118 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 65 | 400 | 500 | 1129.44 | 2.03299 | L_Abluft | 9.75833 | 2640 | 3.66667 | 0.397991 | 244 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 72 | 500 | 550 | 1500 | 3.15 | L_Zuluft | 20.16 | 3100 | 3.13131 | 0.322782 | 68 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 63 | 500 | 550 | 1500 | 3.15 | L_Abluft | 20.16 | 3100 | 3.13131 | 0.322782 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 71 | 500 | 550 | 1500 | 3.15 | L_Zuluft | 20.16 | 3570 | 3.60606 | 0.419207 | 41 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 62 | 500 | 550 | 1500 | 3.15 | L_Abluft | 20.16 | 3570 | 3.60606 | 0.419207 | 168 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 61 | 350 | 200 | 939.558 | 1.03351 | L_Zuluft | 4.96086 | 810 | 3.21429 | 0.515807 | 263 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 62 | 500 | 550 | 1080.68 | 2.26944 | L_Abluft | 14.5244 | 3570 | 3.60606 | 0.30202 | 167 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 84 | 350 | 200 | 1500 | 1.65 | L_Abluft | 7.92 | 810 | 3.21429 | 0.823483 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 84 | 350 | 200 | 1500 | 1.65 | L_Abluft | 7.92 | 810 | 3.21429 | 0.823483 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 84 | 350 | 200 | 1439.56 | 1.58351 | L_Abluft | 7.60086 | 810 | 3.21429 | 0.790301 | 66 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 560 | 3.11111 | 0.918015 | 806 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 560 | 3.11111 | 0.918015 | 807 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 400 | 1500 | 2.1 | L_Abluft | 10.08 | 1500 | 3.47222 | 0.657183 | 823 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 200 | 250 | 1000 | 0.9 | L_Abluft | 4.32 | 630 | 3.5 | 0.760241 | 845 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 56 | 350 | 200 | 1435.51 | 1.57906 | L_Zuluft | 7.57947 | 870 | 3.45238 | 0.899042 | 388 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 450 | 700 | 1000 | 2.3 | L_Abluft | 14.72 | 3440 | 3.03351 | 0.192118 | 429 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 27 | 200 | 200 | 1156.19 | 0.924954 | L_Zuluft | 4.43978 | 475 | 3.29861 | 0.898499 | 706 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 300 | 300 | 1500 | 1.8 | L_Abluft | 8.64 | 1210 | 3.73457 | 0.886573 | 687 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 26 | 300 | 250 | 980.001 | 1.078 | L_Abluft | 5.17441 | 990 | 3.66667 | 0.629835 | 707 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 525 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 250 | 200 | 1400 | 1.26 | L_Zuluft | 6.04801 | 580 | 3.22222 | 0.913932 | 525 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 523 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 522 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 521 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 520 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 523 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 522 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 521 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 520 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 519 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 518 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 517 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 516 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 515 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 514 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 513 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 512 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 511 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 510 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 517 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 516 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 515 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 514 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 513 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 512 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 511 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 510 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 509 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 770 | 3.56481 | 1.07213 | 492 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 508 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 200 | 250 | 1500 | 1.35 | L_Abluft | 6.48 | 580 | 3.22222 | 0.979211 | 507 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 770 | 3.56481 | 1.07213 | 491 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 770 | 3.56481 | 1.07213 | 490 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 770 | 3.56481 | 1.07213 | 489 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 770 | 3.56481 | 1.07213 | 488 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 960 | 3.55556 | 0.910716 | 474 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 960 | 3.55556 | 0.910716 | 473 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 960 | 3.55556 | 0.910716 | 472 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1500 | 1.35 | L_Zuluft | 6.48 | 580 | 3.22222 | 0.979211 | 509 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 250 | 1053.54 | 0.948184 | L_Zuluft | 4.55128 | 580 | 3.22222 | 0.687757 | 508 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 770 | 3.56481 | 1.07213 | 494 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 770 | 3.56481 | 1.07213 | 493 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 770 | 3.56481 | 1.07213 | 492 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 770 | 3.56481 | 1.07213 | 491 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 250 | 200 | 1500 | 1.35 | L_Zuluft | 6.48 | 570 | 3.16667 | 0.948379 | 439 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 250 | 200 | 1500 | 1.35 | L_Zuluft | 6.48 | 570 | 3.16667 | 0.948379 | 438 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 250 | 200 | 1500 | 1.35 | L_Zuluft | 6.48 | 570 | 3.16667 | 0.948379 | 437 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 500 | 200 | 1500 | 2.1 | L_Abluft | 10.08 | 1340 | 3.72222 | 0.935841 | 425 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 500 | 200 | 1500 | 2.1 | L_Abluft | 10.08 | 1340 | 3.72222 | 0.935841 | 424 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 200 | 1300 | 1.82 | L_Abluft | 8.736 | 1740 | 4.83333 | 1.31798 | 414 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1500 | 2.1 | L_Zuluft | 10.08 | 1340 | 3.72222 | 0.935841 | 428 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1500 | 2.1 | L_Zuluft | 10.08 | 1340 | 3.72222 | 0.935841 | 427 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1500 | 2.1 | L_Zuluft | 10.08 | 1340 | 3.72222 | 0.935841 | 426 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1500 | 2.1 | L_Zuluft | 10.08 | 1340 | 3.72222 | 0.935841 | 425 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1500 | 2.1 | L_Zuluft | 10.08 | 1340 | 3.72222 | 0.935841 | 424 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1500 | 2.1 | L_Zuluft | 10.08 | 1340 | 3.72222 | 0.935841 | 423 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 200 | 300 | 1353.34 | 1.35334 | L_Zuluft | 6.49604 | 770 | 3.56481 | 0.967306 | 490 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 250 | 200 | 1459.3 | 1.31337 | L_Zuluft | 6.30419 | 570 | 3.16667 | 0.922648 | 436 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 412 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 411 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 410 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 409 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 408 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 407 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 500 | 200 | 1000 | 1.4 | L_Zuluft | 6.72 | 1340 | 3.72222 | 0.623894 | 422 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 500 | 250 | 1500 | 2.25 | L_Zuluft | 10.8 | 1740 | 3.86667 | 0.830396 | 410 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 500 | 250 | 1500 | 2.25 | L_Zuluft | 10.8 | 1740 | 3.86667 | 0.830396 | 409 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 500 | 250 | 1500 | 2.25 | L_Abluft | 10.8 | 1740 | 3.86667 | 0.830396 | 406 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB |  | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 470 | 3.26389 | 1.1432 |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 470 | 3.26389 | 1.1432 | 575 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 470 | 3.26389 | 1.1432 | 574 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 36 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 550 | 3.81944 | 1.52763 | 222 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 350 | 200 | 1195 | 1.3145 | L_Abluft | 6.3096 | 920 | 3.65079 | 0.829796 | 570 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 470 | 3.26389 | 1.1432 | 573 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 600 | 450 | 1200 | 2.52 | L_Abluft | 16.128 | 3520 | 3.6214 | 0.345676 | 46 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 86 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 88 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 600 | 300 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 400 | 1500 | 3 | L_Abluft | 19.2 | 3080 | 3.56481 | 0.456576 | 59 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 400 | 1500 | 3 | L_Abluft | 19.2 | 3080 | 3.56481 | 0.456576 | 60 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 350 | 1500 | 2.85 | L_Zuluft | 18.24 | 2640 | 3.49206 | 0.486004 | 38 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 350 | 1500 | 2.85 | L_Zuluft | 18.24 | 2640 | 3.49206 | 0.486004 | 39 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 600 | 300 | 1000 | 1.8 | L_Zuluft | 11.52 | 2200 | 3.39506 | 0.347698 | 51 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 500 | 1500 | 2.4 | L_Zuluft | 11.52 | 1760 | 3.25926 | 0.523596 | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 500 | 1500 | 2.4 | L_Zuluft | 11.52 | 1760 | 3.25926 | 0.523596 | 66 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 500 | 1500 | 2.4 | L_Zuluft | 11.52 | 1760 | 3.25926 | 0.523596 | 67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 500 | 1500 | 2.4 | L_Zuluft | 11.52 | 1760 | 3.25926 | 0.523596 | 68 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 500 | 1500 | 2.4 | L_Zuluft | 11.52 | 1760 | 3.25926 | 0.523596 | 69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1320 | 3.49206 | 0.714601 | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1320 | 3.49206 | 0.714601 | 81 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1320 | 3.49206 | 0.714601 | 82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1320 | 3.49206 | 0.714601 | 83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1000 | 1.3 | L_Zuluft | 6.24 | 1320 | 3.49206 | 0.4764 | 84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 89 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1500 | 2.7 | L_Abluft | 17.28 | 2200 | 3.39506 | 0.521548 | 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 300 | 600 | 1110.94 | 1.9997 | L_Abluft | 12.7981 | 2200 | 3.39506 | 0.386273 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1320 | 3.49206 | 0.714601 | 112 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1320 | 3.49206 | 0.714601 | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1320 | 3.49206 | 0.714601 | 114 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1320 | 3.49206 | 0.714601 | 115 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1000 | 1.3 | L_Abluft | 6.24 | 1320 | 3.49206 | 0.4764 | 116 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 350 | 1079.57 | 1.40344 | L_Abluft | 6.7365 | 1320 | 3.49206 | 0.514306 | 117 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 880 | 3.25926 | 0.775611 | 128 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 880 | 3.25926 | 0.775611 | 129 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 880 | 3.25926 | 0.775611 | 130 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 250 | 1000 | 1.1 | L_Abluft | 5.28 | 880 | 3.25926 | 0.517074 | 131 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 12 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 460 | 3.19444 | 1.09887 | 249 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 328 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 317 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 316 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 315 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 314 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 313 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 312 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 311 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 310 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 309 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 308 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 307 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 306 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 305 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 304 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 302 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 301 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 299 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 297 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 296 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 294 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 293 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 292 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 291 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 290 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 289 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 288 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 287 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 286 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 285 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 284 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 283 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 282 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 281 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 279 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 278 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 277 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 276 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 274 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 273 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 272 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 400 | 1500 | 2.1 | L_Zuluft | 10.08 | 1530 | 3.54167 | 0.681698 | 187 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 230 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 231 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 232 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 233 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 234 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 235 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 236 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 237 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 300 | 400 | 1500 | 2.1 | L_Abluft | 10.08 | 1590 | 3.68056 | 0.732009 | 150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 192 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 193 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 194 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 195 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 196 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 198 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 199 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 200 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 201 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1270 | 3.35979 | 0.665395 | 202 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 238 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1500 | 1.95 | L_Zuluft | 9.36 | 1210 | 3.20106 | 0.608527 | 239 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 300 | 350 | 1000 | 1.3 | L_Zuluft | 6.24 | 1210 | 3.20106 | 0.405684 | 240 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1000 | 1 | L_Zuluft | 4.8 | 750 | 3.47222 | 0.68086 | 295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 11 | 200 | 200 | 1409.7 | 1.12776 | L_Abluft | 5.41326 | 520 | 3.61111 | 1.29436 | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 271 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 350 | 1000 | 1.3 | L_Abluft | 6.24 | 1270 | 3.35979 | 0.443597 | 203 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 327 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 326 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 325 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 324 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 323 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 6 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 750 | 3.47222 | 1.02129 | 322 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 303 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 302 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 301 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 300 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 299 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 750 | 3.47222 | 1.02129 | 298 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 11 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 520 | 3.61111 | 1.37727 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 505 | 3.50694 | 1.30488 | 127 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 505 | 3.50694 | 1.30488 | 128 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 300 | 400 | 1500 | 2.1 | L_Abluft | 10.08 | 1590 | 3.68056 | 0.732009 | 149 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 300 | 400 | 1000 | 1.4 | L_Abluft | 6.72 | 1590 | 3.68056 | 0.488006 | 148 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 38 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 39 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 41 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 43 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 44 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 45 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 46 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1500 | 1.8 | L_Abluft | 8.64 | 1000 | 3.47222 | 0.896263 | 47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 300 | 400 | 1500 | 2.1 | L_Zuluft | 10.08 | 1530 | 3.54167 | 0.681698 | 186 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 76 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 77 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 78 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 82 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 83 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 84 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1500 | 1.8 | L_Zuluft | 8.64 | 1000 | 3.47222 | 0.896263 | 86 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 200 | 1000 | 1.2 | L_Abluft | 5.76 | 1000 | 3.47222 | 0.597509 | 48 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 780 | 3.61111 | 1.09799 | 52 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 780 | 3.61111 | 1.09799 | 53 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 200 | 300 | 1500 | 1.5 | L_Abluft | 7.2 | 780 | 3.61111 | 1.09799 | 54 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 200 | 300 | 1092.84 | 1.09284 | L_Abluft | 5.24562 | 780 | 3.61111 | 0.799951 | 55 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 505 | 3.50694 | 1.30488 | 71 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 505 | 3.50694 | 1.30488 | 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 505 | 3.50694 | 1.30488 | 129 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 505 | 3.50694 | 1.30488 | 126 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 505 | 3.50694 | 1.30488 | 125 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 200 | 1000 | 1.2 | L_Zuluft | 5.76 | 1000 | 3.47222 | 0.597509 | 87 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 73 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 74 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 75 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 76 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 77 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 78 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 840 | 3.11111 | 0.711926 | 155 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 840 | 3.11111 | 0.711926 | 156 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 7 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 840 | 3.11111 | 0.711926 | 157 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 10 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 490 | 3.40278 | 1.23435 | 251 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 200 | 200 | 1000 | 0.8 | L_Zuluft | 3.84 | 490 | 3.40278 | 0.822899 | 196 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 200 | 300 | 972 | 0.972 | L_Zuluft | 4.6656 | 740 | 3.42593 | 0.645608 | 181 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 200 | 1500 | 1.5 | L_Abluft | 7.2 | 840 | 3.88889 | 1.2593 | 206 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 200 | 1500 | 1.5 | L_Abluft | 7.2 | 840 | 3.88889 | 1.2593 | 207 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 300 | 200 | 1500 | 1.5 | L_Abluft | 7.2 | 840 | 3.88889 | 1.2593 | 208 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 590 | 3.27778 | 1.01051 | 225 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 9 | 250 | 200 | 1000 | 0.9 | L_Abluft | 4.32 | 590 | 3.27778 | 0.673673 | 226 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 14 | 250 | 550 | 1500 | 2.4 | L_Zuluft | 15.36 | 1960 | 3.9596 | 0.835558 | 34 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 79 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 1960 | 3.62963 | 0.638915 | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 16 | 300 | 500 | 1000 | 1.6 | L_Abluft | 7.68 | 1715 | 3.17593 | 0.332769 | 91 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1225 | 3.24074 | 0.622512 | 126 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1225 | 3.24074 | 0.622512 | 127 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1500 | 1.5 | L_Abluft | 7.2 | 760 | 3.51852 | 1.04656 | 205 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1500 | 1.5 | L_Abluft | 7.2 | 760 | 3.51852 | 1.04656 | 206 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1500 | 1.5 | L_Abluft | 7.2 | 760 | 3.51852 | 1.04656 | 207 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 35 | 300 | 200 | 1000 | 1 | L_Abluft | 4.8 | 760 | 3.51852 | 0.697709 | 209 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 200 | 200 | 1000 | 0.8 | L_Zuluft | 3.84 | 490 | 3.40278 | 0.822899 | 53 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 490 | 3.40278 | 1.23435 | 52 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 490 | 3.40278 | 1.23435 | 98 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 490 | 3.40278 | 1.23435 | 99 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 200 | 200 | 1500 | 1.2 | L_Abluft | 5.76 | 490 | 3.40278 | 1.23435 | 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 735 | 3.40278 | 0.983929 | 112 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1225 | 3.24074 | 0.622512 | 128 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 350 | 300 | 1500 | 1.95 | L_Abluft | 9.36 | 980 | 2.59259 | 0.413028 | 145 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 350 | 300 | 1000 | 1.3 | L_Abluft | 6.24 | 980 | 2.59259 | 0.275352 | 144 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 735 | 3.40278 | 0.983929 | 111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 200 | 300 | 1500 | 1.5 | L_Zuluft | 7.2 | 735 | 3.40278 | 0.983929 | 110 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 490 | 3.40278 | 1.23435 | 122 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 200 | 200 | 1500 | 1.2 | L_Zuluft | 5.76 | 490 | 3.40278 | 1.23435 | 123 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 200 | 200 | 1135.49 | 0.908394 | L_Zuluft | 4.36029 | 490 | 3.40278 | 0.934395 | 125 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 200 | 200 | 1450.67 | 1.16054 | L_Abluft | 5.57059 | 490 | 3.40278 | 1.19376 | 172 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 400 | 450 | 1500 | 2.55 | L_Abluft | 12.24 | 2225 | 3.43364 | 0.496509 | 522 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 21 | 400 | 450 | 1500 | 2.55 | L_Abluft | 12.24 | 2305 | 3.5571 | 0.530068 | 502 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 450 | 1177.37 | 2.00153 | L_Abluft | 9.60735 | 2390 | 3.68827 | 0.444942 | 490 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 400 | 450 | 1500 | 2.55 | L_Zuluft | 12.24 | 2450 | 3.78086 | 0.59355 | 452 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 18 | 400 | 450 | 1500 | 2.55 | L_Zuluft | 12.24 | 2450 | 3.78086 | 0.59355 | 451 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 700 | 600 | 1475 | 3.835 | L_Abluft | 24.544 | 5810 | 3.84259 | 0.359227 | 413 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 600 | 250 | 1500 | 2.55 | L_Abluft | 16.32 | 1935 | 3.58333 | 0.672196 | 807 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 600 | 250 | 1500 | 2.55 | L_Abluft | 16.32 | 1935 | 3.58333 | 0.672196 | 808 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 54 | 400 | 250 | 1492.14 | 1.93978 | L_Zuluft | 9.31095 | 1305 | 3.625 | 0.808959 | 385 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 700 | 600 | 1475 | 3.835 | L_Zuluft | 24.544 | 5740 | 3.7963 | 0.351217 | 380 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 61 | 350 | 200 | 1500 | 1.65 | L_Zuluft | 7.92 | 810 | 3.21429 | 0.823483 | 262 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 71 | 500 | 550 | 1500 | 3.15 | L_Zuluft | 20.16 | 3570 | 3.60606 | 0.419207 | 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 200 | 200 | 1257.23 | 1.00578 | L_Abluft | 4.82776 | 500 | 3.47222 | 1.07381 | 274 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 500 | 500 | 1050 | 2.1 | L_Abluft | 10.08 | 3300 | 3.66667 | 0.320356 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 15 | 300 | 500 | 1000 | 1.6 | L_Abluft | 7.68 | 1960 | 3.62963 | 0.425943 | 68 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 200 | 300 | 1302.15 | 1.30215 | L_Abluft | 6.2503 | 780 | 3.61111 | 0.953163 | 51 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 600 | 450 | 1500 | 3.15 | L_Abluft | 20.16 | 3520 | 3.6214 | 0.432095 | 44 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 400 | 1500 | 3 | L_Abluft | 19.2 | 3080 | 3.56481 | 0.456576 | 57 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 400 | 1475 | 2.95 | L_Abluft | 18.88 | 3080 | 3.56481 | 0.448966 | 58 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 2 | 600 | 450 | 1475 | 3.0975 | L_Zuluft | 19.824 | 3520 | 3.6214 | 0.424893 | 11 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 4 | 600 | 350 | 1500 | 2.85 | L_Zuluft | 18.24 | 2640 | 3.49206 | 0.486004 | 37 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 2 | 600 | 450 | 1500 | 3.15 | L_Zuluft | 20.16 | 3520 | 3.6214 | 0.432095 | 9 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 600 | 500 | 925.047 | 2.0351 | L_Abluft | 13.0247 | 4110 | 3.80556 | 0.271938 | 187 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 400 | 500 | 1000 | 1.8 | L_Abluft | 8.64 | 2570 | 3.56944 | 0.335255 | 450 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2570 | 3.56944 | 0.502882 | 451 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 500 | 400 | 1500 | 2.7 | L_Abluft | 12.96 | 2570 | 3.56944 | 0.502882 | 453 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 500 | 400 | 1500 | 2.7 | L_Abluft | 12.96 | 2570 | 3.56944 | 0.502882 | 454 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 3 | 600 | 500 | 925.047 | 2.0351 | L_Zuluft | 13.0247 | 3640 | 3.37037 | 0.217078 | 184 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 172 | 700 | 500 | 1378.31 | 3.30795 | L_Zuluft | 21.1709 | 4720 | 3.74603 | 0.362589 | 322 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 5 | 700 | 500 | 1000 | 2.4 | L_Abluft | 15.36 | 4961 | 3.9373 | 0.288594 | 470 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 8 | 400 | 450 | 1201.43 | 2.04243 | L_Abluft | 9.80369 | 2306 | 3.55864 | 0.424902 | 496 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 48 | 350 | 300 | 1000 | 1.3 | L_Abluft | 6.24 | 1350 | 3.57143 | 0.496616 | 253 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 181 | 300 | 350 | 1000 | 1.3 | L_Zuluft | 6.24 | 1442 | 3.81481 | 0.561099 | 64 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 180 | 350 | 450 | 1000 | 1.6 | L_Zuluft | 7.68 | 2163 | 3.81481 | 0.439945 | 55 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 167 | 300 | 350 | 1000 | 1.3 | L_Zuluft | 6.24 | 1442 | 3.81481 | 0.561099 | 97 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 500 | 350 | 1251.03 | 2.12675 | L_Zuluft | 10.2084 | 2202 | 3.49524 | 0.443016 | 538 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 78 | 500 | 300 | 1076.03 | 1.72165 | L_Abluft | 8.26391 | 2000 | 3.7037 | 0.47581 | 60 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 62 | 700 | 400 | 1076.03 | 2.36727 | L_Abluft | 15.1505 | 3600 | 3.57143 | 0.305847 | 146 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 55 | 650 | 300 | 1500 | 2.85 | L_Abluft | 18.24 | 2700 | 3.84615 | 0.636588 | 212 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 55 | 650 | 300 | 1017.34 | 1.93294 | L_Abluft | 12.3708 | 2700 | 3.84615 | 0.431751 | 213 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 36 | 800 | 400 | 1026.03 | 2.46247 | L_Abluft | 15.7598 | 4500 | 3.90625 | 0.325429 | 319 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
