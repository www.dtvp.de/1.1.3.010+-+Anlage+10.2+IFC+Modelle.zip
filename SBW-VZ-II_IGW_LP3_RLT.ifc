Properties of the parts of a building model (IFC2X3), part 3 of 18

# IfcFlowFitting: Bogen (860)
Name | In | Section No | Geom-Diameter (mm) (mm) = Geom-Radius (mm) (mm) | Geom-Angle (°) (rad) | Tech-Medium | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Abbreviation | Floor | Floor No. | Building = Building No.
Bogen | EG_Verwaltung_FFB | 25 | 100 | 90 | L_Zuluft | 1.88457 | 158 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 100 | 90 | L_Zuluft | 1.88457 | 160 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 100 | 90 | L_Abluft | 1.88457 | 96 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 100 | 90 | L_Abluft | 1.88457 | 98 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 160 | 90 | L_Abluft | 2.68481 | 62 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 160 | 90 | L_Abluft | 2.68481 | 58 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 160 | 90 | L_Abluft | 2.68481 | 74 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 125 | 90 | L_Abluft | 1.86786 | 111 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 125 | 90 | L_Abluft | 1.86786 | 114 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 125 | 90 | L_Zuluft | 1.86786 | 173 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 125 | 90 | L_Zuluft | 1.86786 | 176 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 160 | 90 | L_Zuluft | 2.68481 | 137 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 160 | 90 | L_Zuluft | 2.68481 | 133 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 45 | L_Abluft | 1.25268 | 121 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 45 | L_Abluft | 1.25268 | 123 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 45 | L_Abluft | 1.25268 | 125 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 45 | L_Abluft | 1.25268 | 127 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 160 | 90 | L_Zuluft | 2.68481 | 117 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 160 | 90 | L_Zuluft | 2.68481 | 113 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 90 | L_Abluft | 1.71828 | 135 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 160 | 90 | L_Zuluft | 1.71828 | 98 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 90 | L_Abluft | 1.71828 | 139 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 160 | 90 | L_Zuluft | 1.71828 | 102 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 90 | L_Zuluft | 2.21885 | 226 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 90 | L_Zuluft | 2.21885 | 228 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 160 | 45 | L_Zuluft | 1.61761 | 245 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 160 | 90 | L_Abluft | 2.21885 | 282 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 160 | 90 | L_Abluft | 2.21885 | 284 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 160 | 45 | L_Zuluft | 1.61761 | 237 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 160 | 45 | L_Zuluft | 1.61761 | 239 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 160 | 45 | L_Zuluft | 1.61761 | 241 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 160 | 90 | L_Abluft | 2.04489 | 266 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 160 | 90 | L_Abluft | 2.04489 | 268 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 45 | L_Abluft | 1.61761 | 297 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 45 | L_Abluft | 1.61761 | 291 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 45 | L_Abluft | 1.61761 | 293 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 160 | 90 | L_Zuluft | 2.21885 | 188 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 160 | 90 | L_Zuluft | 2.21885 | 190 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 160 | 90 | L_Abluft | 2.21885 | 217 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 160 | 90 | L_Abluft | 2.21885 | 219 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Zuluft | 2.32663 | 167 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Zuluft | 2.32663 | 170 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Zuluft | 2.32663 | 163 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Abluft | 2.32663 | 236 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Abluft | 2.32663 | 239 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Abluft | 2.32663 | 232 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 200 | 90 | L_Abluft | 2.94465 | 624 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 100 | 90 | L_Abluft | 0.372262 | 322 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 100 | 90 | L_Abluft | 0.372262 | 324 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 100 | 90 | L_Zuluft | 0.372262 | 329 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 100 | 90 | L_Zuluft | 0.372262 | 331 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 100 | 90 | L_Abluft | 0.372262 | 326 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 44 | 100 | 90 | L_Abluft | 0.372262 | 307 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 100 | 90 | L_Zuluft | 0.372262 | 313 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 100 | 90 | L_Zuluft | 0.372262 | 315 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 44 | 100 | 90 | L_Abluft | 0.372262 | 309 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 46 | 100 | 90 | L_Abluft | 0.372262 | 265 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 36 | 100 | 90 | L_Zuluft | 0.372262 | 287 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 100 | 90 | L_Zuluft | 0.837588 | 274 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 45 | 100 | 90 | L_Abluft | 0.837588 | 283 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 100 | 90 | L_Abluft | 0.372262 | 313 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 100 | 90 | L_Zuluft | 0.372262 | 319 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 82 | 160 | 90 | L_Abluft | 1.96058 | 191 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 82 | 160 | 90 | L_Abluft | 1.96058 | 193 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Zuluft | 1.96058 | 49 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Zuluft | 1.96058 | 51 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 2 | 200 | 90 | L_Abluft | 4.0847 | 11 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 160 | 90 | L_Abluft | 2.13099 | 120 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 160 | 90 | L_Zuluft | 2.13099 | 70 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 160 | 90 | L_Abluft | 2.13099 | 105 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 160 | 45 | L_Zuluft | 1.55356 | 64 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 160 | 45 | L_Abluft | 1.55356 | 114 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 160 | 90 | L_Zuluft | 2.13099 | 86 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 160 | 90 | L_Zuluft | 2.13099 | 37 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 20 | 160 | 90 | L_Zuluft | 2.13099 | 132 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 160 | 90 | L_Abluft | 2.13099 | 83 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 90 | L_Abluft | 2.13099 | 158 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 160 | 90 | L_Abluft | 2.13099 | 148 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 90 | L_Zuluft | 2.13099 | 99 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 90 | L_Zuluft | 2.13099 | 95 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 160 | 90 | L_Zuluft | 2.13099 | 82 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 160 | 90 | L_Abluft | 2.13099 | 136 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 160 | 90 | L_Abluft | 2.13099 | 132 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 40 | 125 | 90 | L_Zuluft | 1.26033 | 596 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 44 | 180 | 90 | L_Abluft | 2.34102 | 524 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 100 | 90 | L_Abluft | 1.48905 | 505 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 54 | 100 | 90 | L_Abluft | 1.68099 | 493 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 180 | 90 | L_Zuluft | 2.79315 | 471 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Zuluft | 1.48905 | 455 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 125 | 90 | L_Zuluft | 1.3723 | 437 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 56 | 125 | 90 | L_Abluft | 1.3723 | 459 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 100 | 90 | L_Abluft | 0.837588 | 471 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 200 | 90 | L_Zuluft | 2.75161 | 783 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 200 | 90 | L_Zuluft | 2.75161 | 785 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 140 | 90 | L_Zuluft | 2.18637 | 478 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 140 | 90 | L_Zuluft | 2.67088 | 810 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 140 | 45 | L_Zuluft | 1.94716 | 812 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 140 | 45 | L_Zuluft | 1.94716 | 814 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 140 | 90 | L_Abluft | 2.18637 | 476 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 140 | 45 | L_Abluft | 1.67893 | 559 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 140 | 45 | L_Abluft | 1.67893 | 561 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 83 | 160 | 90 | L_Abluft | 1.96058 | 180 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 92 | 160 | 90 | L_Abluft | 1.96058 | 88 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 100 | 90 | L_Zuluft | 2.81523 | 835 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 20 | 140 | 90 | L_Zuluft | 2.18637 | 442 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 53 | 100 | 60 | L_Abluft | 1.08556 | 509 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 60 | L_Zuluft | 1.08556 | 459 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 100 | 90 | L_Abluft | 0.837588 | 479 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 100 | 90 | L_Abluft | 0.837588 | 482 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 100 | 90 | L_Abluft | 0.837588 | 484 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 100 | 90 | L_Abluft | 0.837588 | 486 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 55 | 100 | 45 | L_Abluft | 0.610629 | 475 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 30 | 125 | 15 | L_Zuluft | 0.773195 | 758 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 30 | 125 | 15 | L_Zuluft | 0.773195 | 760 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 45 | L_Zuluft | 1.17414 | 860 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 140 | 30 | L_Abluft | 1.37177 | 544 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Abluft | 2.75161 | 812 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Abluft | 2.75161 | 818 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 122 | 160 | 45 | L_Zuluft | 2.73377 | 293 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 122 | 160 | 45 | L_Zuluft | 2.73377 | 295 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 124 | 160 | 45 | L_Zuluft | 2.73377 | 278 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 124 | 160 | 45 | L_Zuluft | 2.73377 | 276 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 126 | 160 | 45 | L_Zuluft | 2.73377 | 260 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 126 | 160 | 45 | L_Zuluft | 2.73377 | 258 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 128 | 160 | 45 | L_Zuluft | 2.73377 | 245 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 128 | 160 | 45 | L_Zuluft | 2.73377 | 243 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
8 x Bogen | EG_Verwaltung_FFB |  | 250 | 90 | L_Umluft |  |  | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
8 x Bogen | EG_Verwaltung_FFB |  | 200 | 90 | L_Umluft |  |  | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 175 | 280 | 90 | L_Zuluft | 2.07335 | 403 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 200 | 90 | L_Abluft | 2.94465 | 631 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 200 | 90 | L_Zuluft | 2.94465 | 194 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 200 | 90 | L_Zuluft | 2.94465 | 192 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 41 | 200 | 90 | L_Zuluft | 2.94465 | 188 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 31 | 125 | 90 | L_Abluft | 2.43965 | 401 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 125 | 90 | L_Zuluft | 2.43965 | 402 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 31 | 125 | 90 | L_Abluft | 2.43965 | 399 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 31 | 125 | 90 | L_Abluft | 2.43965 | 394 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 200 | 90 | L_Abluft | 1.48905 | 385 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 200 | 90 | L_Abluft | 1.48905 | 383 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 125 | 90 | L_Zuluft | 2.43965 | 397 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 23 | 200 | 90 | L_Zuluft | 1.48905 | 386 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 45 | L_Abluft | 1.61761 | 295 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 160 | 45 | L_Zuluft | 1.61761 | 243 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Abluft | 2.32663 | 230 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 160 | 90 | L_Zuluft | 2.21885 | 198 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 13 | 100 | 90 | L_Zuluft | 2.32663 | 161 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 14 | 160 | 90 | L_Abluft | 2.21885 | 212 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 160 | 90 | L_Zuluft | 2.21885 | 221 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 160 | 45 | L_Zuluft | 1.61761 | 235 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 160 | 90 | L_Zuluft | 2.21885 | 183 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 160 | 90 | L_Zuluft | 2.13099 | 139 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 160 | 90 | L_Zuluft | 2.13099 | 55 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 160 | 45 | L_Zuluft | 1.55356 | 66 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 160 | 90 | L_Abluft | 2.21885 | 277 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 12 | 160 | 90 | L_Abluft | 2.21885 | 253 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 160 | 45 | L_Abluft | 1.55356 | 116 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 15 | 100 | 90 | L_Abluft | 0.837588 | 254 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 45 | L_Zuluft | 0.610629 | 341 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 45 | L_Zuluft | 0.610629 | 343 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 100 | 45 | L_Abluft | 0.610629 | 321 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 9 | 100 | 45 | L_Abluft | 0.610629 | 323 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 45 | L_Abluft | 0.610629 | 306 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 100 | 45 | L_Abluft | 0.610629 | 308 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 62 | 180 | 45 | L_Zuluft | 1.86785 | 290 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 62 | 180 | 45 | L_Zuluft | 1.86785 | 288 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 85 | 180 | 45 | L_Abluft | 1.86785 | 96 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 85 | 180 | 45 | L_Abluft | 1.86785 | 94 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Abluft | 2.18637 | 461 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Abluft | 2.18637 | 463 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 140 | 90 | L_Zuluft | 2.18637 | 480 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 140 | 90 | L_Zuluft | 2.18637 | 482 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 11 | 140 | 90 | L_Zuluft | 0.732827 | 850 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 45 | L_Abluft | 1.17414 | 902 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 10 | 125 | 45 | L_Abluft | 1.17414 | 904 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 600 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 602 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Abluft | 0.837588 | 604 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 548 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 550 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 100 | 90 | L_Zuluft | 0.837588 | 552 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 125 | 90 | L_Zuluft | 1.26033 | 477 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 45 | L_Zuluft | 0.610629 | 490 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Zuluft | 0.837588 | 492 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Zuluft | 0.837588 | 494 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Zuluft | 0.837588 | 499 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Zuluft | 0.837588 | 501 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Zuluft | 0.837588 | 503 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Abluft | 0.837588 | 530 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 52 | 100 | 90 | L_Abluft | 0.837588 | 532 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 45 | 200 | 90 | L_Zuluft | 4.0847 | 177 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 40 | 140 | 90 | L_Zuluft | 2.67088 | 213 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 200 | 90 | L_Zuluft | 2.68872 | 231 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Zuluft | 2.67088 | 347 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 90 | L_Abluft | 1.3723 | 339 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 90 | L_Abluft | 1.3723 | 341 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 45 | L_Abluft | 1.00045 | 345 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 125 | 90 | L_Zuluft | 1.3723 | 361 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 125 | 90 | L_Zuluft | 1.3723 | 359 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 125 | 45 | L_Zuluft | 1.00045 | 365 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 7 | 200 | 45 | L_Abluft | 2.14674 | 626 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 27 | 100 | 90 | L_Abluft | 1.88457 | 88 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 25 | 100 | 90 | L_Zuluft | 1.88457 | 150 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 125 | 90 | L_Abluft | 1.86786 | 105 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 125 | 90 | L_Abluft | 1.86786 | 107 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 125 | 90 | L_Zuluft | 1.86786 | 167 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 24 | 125 | 90 | L_Zuluft | 1.86786 | 169 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 45 | L_Abluft | 1.25268 | 131 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 160 | 45 | L_Zuluft | 1.25268 | 94 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 22 | 160 | 45 | L_Abluft | 1.25268 | 133 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 160 | 45 | L_Zuluft | 1.25268 | 96 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Zuluft | 2.43965 | 197 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 20 | 125 | 90 | L_Abluft | 2.43965 | 160 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 19 | 125 | 90 | L_Abluft | 2.43965 | 179 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 125 | 90 | L_Zuluft | 2.43965 | 216 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 21 | 160 | 45 | L_Abluft | 1.55356 | 174 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 21 | 160 | 45 | L_Abluft | 1.55356 | 176 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 21 | 160 | 45 | L_Abluft | 1.55356 | 178 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 21 | 160 | 45 | L_Abluft | 1.55356 | 180 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 20 | 160 | 90 | L_Abluft | 2.13099 | 191 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 21 | 160 | 90 | L_Abluft | 2.13099 | 185 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 180 | 45 | L_Zuluft | 1.7596 | 337 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 180 | 45 | L_Zuluft | 1.7596 | 341 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 26 | 180 | 45 | L_Zuluft | 1.7596 | 343 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 45 | L_Abluft | 1.00045 | 334 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 125 | 45 | L_Abluft | 1.00045 | 336 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 100 | 45 | L_Abluft | 0.831134 | 124 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 90 | 100 | 45 | L_Abluft | 0.831134 | 126 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 18 | 140 | 90 | L_Zuluft | 2.18637 | 475 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 28 | 140 | 90 | L_Abluft | 2.18637 | 456 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 200 | 45 | L_Zuluft | 1.96016 | 235 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 29 | 200 | 45 | L_Zuluft | 1.96016 | 233 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 45 | L_Abluft | 0.271391 | 232 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 38 | 100 | 45 | L_Zuluft | 0.271391 | 253 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 39 | 140 | 60 | L_Zuluft | 2.27283 | 240 | BGF | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 47 | 140 | 45 | L_Abluft | 1.94716 | 249 | BGF | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 37 | 100 | 45 | L_Zuluft | 0.610629 | 272 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 45 | 100 | 90 | L_Abluft | 0.837588 | 282 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 35 | 100 | 45 | L_Zuluft | 0.271391 | 305 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 44 | 100 | 45 | L_Abluft | 0.271391 | 298 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 43 | 100 | 45 | L_Abluft | 0.271391 | 315 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 34 | 100 | 45 | L_Zuluft | 0.271391 | 321 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 100 | 45 | L_Abluft | 0.610629 | 548 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 100 | 90 | L_Abluft | 0.837588 | 550 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 51 | 100 | 90 | L_Abluft | 0.837588 | 552 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 45 | L_Zuluft | 0.610629 | 509 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 90 | L_Zuluft | 0.837588 | 511 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 49 | 100 | 90 | L_Zuluft | 0.837588 | 513 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Zuluft | 0.837588 | 530 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 48 | 100 | 90 | L_Zuluft | 0.837588 | 532 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 45 | L_Abluft | 0.610629 | 568 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Abluft | 0.837588 | 570 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 50 | 100 | 90 | L_Abluft | 0.837588 | 572 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 5 | 400 | 90 | L_Abluft | 4.29939 | 27 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 4 | 400 | 90 | L_Abluft | 4.29939 | 37 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 4 | 400 | 90 | L_Abluft | 4.29939 | 39 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 6 | 250 | 90 | L_Abluft | 2.51649 | 19 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB | 57 | 200 | 90 | L_Abluft | 2.75161 | 443 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 250 | 15 | L_Umluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 32 | 200 | 90 | L_Zuluft | 1.48905 | 385 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x Bogen | EG_Verwaltung_FFB |  | 160 | 45 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 280 | 90 | L_Zuluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB |  | 280 | 90 | L_Zuluft | 2.03933 |  | BGE
Bogen | EG_Verwaltung_FFB |  | 200 | 90 | L_Abluft | 2.94465 |  | BGE
Bogen | EG_Verwaltung_FFB | 85 | 180 | 90 | L_Abluft | 1.99471 | 160 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 180 | 45 | L_Abluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB |  | 180 | 45 | L_Zuluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB | 88 | 125 | 90 | L_Zuluft | 1.86786 | 146 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 100 | 45 | L_Abluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB |  | 200 | 30 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 100 | 60 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 100 | 60 | L_Abluft |  |  | BGE
3 x Bogen | EG_Verwaltung_FFB |  | 200 | 30 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 16 | 200 | 90 | L_Zuluft | 2.75161 | 818 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB |  | 180 | 15 | L_Zuluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB |  | 180 | 15 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 14 | 140 | 90 | L_Zuluft | 2.30295 | 527 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 140 | 60 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 2 | 200 | 90 | L_Zuluft | 4.0847 | 11 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 200 | 90 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 49 | 100 | 45 | L_Abluft | 1.68099 | 592 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 200 | 90 | L_Abluft | 1.48905 | 378 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB | 32 | 200 | 60 | L_Abluft | 1.48905 | 378 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 200 | 90 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 125 | 45 | L_Zuluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB |  | 140 | 15 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 125 | 45 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 140 | 90 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 140 | 45 | L_Zuluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 10 | 100 | 30 | L_Zuluft | 0.837588 | 348 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB | 18 | 140 | 30 | L_Abluft | 2.18637 | 470 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB | 18 | 140 | 30 | L_Zuluft | 2.18637 | 470 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen | EG_Verwaltung_FFB |  | 140 | 30 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB |  | 140 | 30 | L_Zuluft |  |  | BGE
2 x Bogen | EG_Verwaltung_FFB |  | 100 | 90 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 37 | 125 | 60 | L_Abluft | 1.00045 | 330 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen | EG_Verwaltung_FFB |  | 125 | 60 | L_Abluft |  |  | BGE
Bogen | EG_Verwaltung_FFB | 49 | 140 | 90 | L_Abluft | 2.67088 | 212 | BGE | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: Bogen asymmetrisch (57)
Description: Bogen asymmetrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Bogen asymmetrisch; Abbreviation: BA
Name | In | Section No | Geom-Thickness (mm) (mm) | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Radius (mm) (mm) | Geom-Angle (°) (rad) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Bogen asymmetrisch | Wartung_FFB | 28 | 918 | 500 | 612 | 100 | 90 | 3.72833 | L_Aussenluft | 23.8613 | 1.76938 | 264 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 25 | 600 | 1000 | 1400 | 100 | 90 | 9.82478 | L_Abluft | 78.5982 | 3.39042 | 81 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 7 | 600 | 1000 | 1400 | 100 | 90 | 9.82478 | L_Abluft | 78.5982 | 3.39042 | 141 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 4 | 2142 | 2000 | 2448 | 100 | 90 | 37.6599 | L_Abluft | 331.407 | 2.17845 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 4 | 2000 | 1200 | 2142 | 100 | 90 | 30.0024 | L_Abluft | 264.021 | 3.55023 | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 193 | 2448 | 2000 | 2448 | 100 | 90 | 40.1706 | L_Aussenluft | 353.501 | 3.47645 | 653 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 193 | 2448 | 1400 | 2000 | 100 | 90 | 30.2346 | L_Aussenluft | 266.064 | 4.99323 | 655 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 81 | 2448 | 2448 | 2000 | 100 | 90 | 40.1706 | L_Fortluft | 353.501 | 2.89693 | 528 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 81 | 2448 | 1400 | 2000 | 100 | 90 | 30.2346 | L_Fortluft | 266.064 | 4.16087 | 530 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 3 | 700 | 700 | 600 | 100 | 90 | 3.79858 | L_Abluft | 24.3109 | 6.19459 | 407 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 3 | 700 | 600 | 700 | 100 | 90 | 3.79858 | L_Abluft | 24.3109 | 5.54185 | 409 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 1 | 2000 | 1800 | 1600 | 100 | 30 | 12.1192 | L_Abluft | 96.954 | 2.75475 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 7 | 700 | 750 | 1000 | 100 | 45 | 3.27739 | L_Zuluft | 20.9753 | 2.57395 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 6 | 700 | 750 | 1000 | 100 | 45 | 3.27739 | L_Zuluft | 20.9753 | 2.57395 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 6 | 700 | 750 | 1000 | 100 | 45 | 3.27739 | L_Zuluft | 20.9753 | 3.31693 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 7 | 700 | 750 | 1000 | 100 | 45 | 3.27739 | L_Zuluft | 20.9753 | 3.31693 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 4 | 800 | 750 | 1000 | 100 | 45 | 3.47018 | L_Zuluft | 22.2091 | 2.87469 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 4 | 800 | 750 | 1000 | 100 | 45 | 3.47018 | L_Zuluft | 22.2091 | 3.57339 | 59 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 3 | 800 | 750 | 1000 | 100 | 45 | 4.7759 | L_Zuluft | 30.5657 | 2.87469 | 63 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 3 | 800 | 750 | 1000 | 100 | 45 | 4.24094 | L_Zuluft | 27.142 | 3.57339 | 68 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 10 | 800 | 750 | 1000 | 100 | 45 | 3.47018 | L_Zuluft | 22.2091 | 2.87469 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 10 | 800 | 750 | 1000 | 100 | 45 | 3.47018 | L_Zuluft | 22.2091 | 3.57339 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 9 | 800 | 750 | 1000 | 100 | 45 | 4.7759 | L_Zuluft | 30.5657 | 2.87469 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB | 9 | 800 | 750 | 1000 | 100 | 45 | 4.24094 | L_Zuluft | 27.142 | 3.57339 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | Wartung_FFB |  | 400 | 1000 | 800 | 0 | 90 | 4.67823 | L_Zuluft | 29.9407 | 5.60649
Bogen asymmetrisch | Wartung_FFB |  | 500 | 1300 | 800 | 100 | 90 | 8.36753 | L_Zuluft | 66.9403 | 3.23348
Bogen asymmetrisch | Wartung_FFB |  | 600 | 500 | 600 | 0 | 45 | 1.40049 | L_Zuluft | 8.96316
Bogen asymmetrisch | EG_Verwaltung_FFB | 17 | 500 | 200 | 300 | 100 | 90 | 1.08531 | L_Abluft | 5.20949 | 3.56938 | 430 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 8 | 500 | 200 | 300 | 100 | 90 | 1.08531 | L_Zuluft | 5.20949 | 2.88244 | 433 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 3 | 400 | 300 | 500 | 100 | 90 | 1.87646 | L_Abluft | 9.00701 | 3.10756 | 144 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 4 | 400 | 300 | 500 | 100 | 90 | 1.87646 | L_Zuluft | 9.00701 | 1.941 | 181 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 16 | 200 | 400 | 200 | 50 | 90 | 1 | L_Abluft | 4.6475 | 0.826142 | 478 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 7 | 200 | 400 | 200 | 50 | 90 | 1 | L_Abluft | 4.6475 | 0.82998 | 522 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen asymmetrisch | EG_Verwaltung_FFB | 10 | 200 | 400 | 200 | 50 | 90 | 1 | L_Abluft | 4.6475 | 3.56243 | 505 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 9 | 200 | 400 | 200 | 50 | 90 | 1 | L_Abluft | 4.6475 | 1.18413 | 515 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 9 | 400 | 200 | 450 | 50 | 90 | 1.50518 | L_Abluft | 7.22485 | 0.805507 | 509 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Bogen asymmetrisch | EG_Verwaltung_FFB | 76 | 400 | 200 | 300 | 100 | 90 | 1.04639 | L_Abluft | 5.02265 | 5.02336 | 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 65 | 400 | 200 | 300 | 100 | 90 | 1.04639 | L_Abluft | 5.02265 | 2.2326 | 169 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 68 | 400 | 200 | 300 | 100 | 90 | 1.04639 | L_Abluft | 5.02265 | 2.2326 | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 59 | 400 | 250 | 200 | 100 | 90 | 1 | L_Abluft | 4.05462 | 5.51363 | 207 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 56 | 400 | 250 | 200 | 100 | 90 | 1 | L_Abluft | 4.05462 | 5.51363 | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 57 | 400 | 200 | 300 | 100 | 90 | 1.01965 | L_Abluft | 4.8943 | 5.02336 | 219 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 42 | 400 | 200 | 300 | 100 | 90 | 1.04639 | L_Abluft | 5.02265 | 3.48845 | 326 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 39 | 400 | 200 | 300 | 100 | 90 | 1.04639 | L_Abluft | 5.02265 | 3.48845 | 340 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB | 3 | 600 | 500 | 450 | 100 | 90 | 2.29345 | L_Zuluft | 14.6781 | 5.74 | 185 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 200 | 200 | 400 | 100 | 90 | 1.18524 | L_Abluft | 5.68914 | 2.30489
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 400 | 200 | 350 | 0 | 90 | 1.12662 | L_Abluft | 5.40777 | 6.08934
Bogen asymmetrisch | EG_Verwaltung_FFB | 56 | 400 | 250 | 200 | 100 | 90 | 1 | L_Abluft | 4.05462 | 3.02531 | 227 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 400 | 200 | 300 | 100 | 90 | 1.08125 | L_Abluft | 5.18998 | 2.7563
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 400 | 250 | 200 | 100 | 90 | 1 | L_Abluft | 4.05462 | 5.51363
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 400 | 350 | 200 | 100 | 90 | 1.21029 | L_Abluft | 5.80938 | 4.55061
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 350 | 400 | 800 | 50 | 90 | 3.30091 | L_Abluft | 21.1258 | 1.572
2 x Bogen asymmetrisch | EG_Verwaltung_FFB |  | 400 | 300 | 200 | 100 | 90 | 1.25639 | L_Abluft | 6.03065 | 3.48845
Bogen asymmetrisch | EG_Verwaltung_FFB |  | 400 | 300 | 200 | 0 | 90 | 1.03955 | L_Abluft | 4.98986

# IfcFlowFitting: Bogen symmetrisch (442)
Description: Bogen symmetrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Bogen symmetrisch; Abbreviation: BS
Name | In | Section No | Geom-Thickness (mm) (mm) | Geom-Side 1 (mm) (mm) = Geom-Side 2 (mm) (mm) | Geom-Radius (mm) (mm) | Geom-Angle (°) (rad) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Bogen symmetrisch | Wartung_FFB | 2 | 700 | 600 | 100 | 90 | 3.11885 | L_Zuluft | 19.9606 | 6.88709 | 369 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 1530 | 918 | 100 | 45 | 4.40412 | L_Aussenluft | 35.233 | 1.76768 | 874 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 1530 | 918 | 100 | 45 | 4.40412 | L_Aussenluft | 35.233 | 1.76768 | 876 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 90 | 6.01487 | L_Aussenluft | 38.4951 | 6.1628 | 902 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 90 | 6.01487 | L_Aussenluft | 38.4951 | 6.1628 | 886 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 93 | 900 | 900 | 100 | 90 | 6.01487 | L_Aussenluft | 38.4951 | 6.1628 | 884 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 90 | 6.01487 | L_Fortluft | 38.4951 | 6.1628 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 900 | 900 | 100 | 90 | 6.01487 | L_Fortluft | 38.4951 | 6.1628 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 1530 | 918 | 100 | 45 | 4.40412 | L_Abluft | 35.233 | 1.76768 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 1530 | 918 | 100 | 45 | 4.40412 | L_Abluft | 35.233 | 1.76768 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 3 | 700 | 600 | 100 | 90 | 3.11885 | L_Abluft | 19.9606 | 7.05609 | 400 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 918 | 612 | 100 | 45 | 2.01716 | L_Aussenluft | 12.9098 | 0.990691 | 258 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 28 | 918 | 612 | 100 | 45 | 2.01716 | L_Aussenluft | 12.9098 | 0.990691 | 256 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 918 | 612 | 100 | 45 | 2.01716 | L_Abluft | 12.9098 | 0.990691 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 918 | 612 | 100 | 45 | 2.01716 | L_Abluft | 12.9098 | 0.990691 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Zuluft | 10.0078 | 4.92067 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 500 | 500 | 100 | 90 | 2.08496 | L_Abluft | 10.0078 | 4.92067 | 44 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 500 | 500 | 100 | 90 | 2.08496 | L_Abluft | 10.0078 | 4.92067 | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 500 | 500 | 100 | 90 | 2.08496 | L_Abluft | 10.0078 | 4.92067 | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 500 | 500 | 100 | 90 | 2.08496 | L_Abluft | 10.0078 | 4.92067 | 59 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Zuluft | 10.0078 | 4.92067 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Zuluft | 10.0078 | 4.92067 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Fortluft | 10.0078 | 4.92067 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 500 | 100 | 90 | 2.08496 | L_Fortluft | 10.0078 | 4.92067 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 30 | 400 | 500 | 100 | 90 | 1.87646 | L_Fortluft | 9.00701 | 3.81831 | 373 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 612 | 612 | 100 | 45 | 1.61373 | L_Aussenluft | 10.3279 | 0.978261 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 612 | 612 | 100 | 45 | 1.61373 | L_Aussenluft | 10.3279 | 0.978261 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 612 | 612 | 100 | 45 | 1.61373 | L_Abluft | 10.3279 | 1.02521 | 4 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 612 | 612 | 100 | 45 | 1.61373 | L_Abluft | 10.3279 | 1.02521 | 2 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 30 | 500 | 400 | 100 | 90 | 1.59372 | L_Fortluft | 7.64984 | 4.78771 | 367 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 90 | 1.87646 | L_Aussenluft | 9.00701 | 3.81831 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 45 | 1.02823 | L_Aussenluft | 4.9355 | 2.58733 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 45 | 1.02823 | L_Aussenluft | 4.9355 | 2.58733 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 400 | 500 | 100 | 90 | 1.87646 | L_Zuluft | 9.00701 | 3.81831 | 67 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 400 | 500 | 100 | 90 | 1.87646 | L_Zuluft | 9.00701 | 3.81831 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 400 | 500 | 100 | 90 | 1.87646 | L_Zuluft | 9.00701 | 3.81831 | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 400 | 100 | 90 | 1.59372 | L_Abluft | 7.64984 | 5.01749 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 90 | 1.87646 | L_Abluft | 9.00701 | 4.00157 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 90 | 1.87646 | L_Abluft | 9.00701 | 4.00157 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 500 | 400 | 100 | 90 | 1.59372 | L_Abluft | 7.64984 | 5.01749 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 400 | 500 | 100 | 90 | 1.87646 | L_Abluft | 9.00701 | 4.00157 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 918 | 612 | 100 | 45 | 2.01716 | L_Aussenluft | 12.9098 | 1.12719 | 122 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 918 | 612 | 100 | 45 | 2.01716 | L_Aussenluft | 12.9098 | 1.12719 | 120 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 918 | 612 | 100 | 45 | 2.01716 | L_Abluft | 12.9098 | 1.12719 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 918 | 612 | 100 | 45 | 2.01716 | L_Abluft | 12.9098 | 1.12719 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 600 | 450 | 100 | 90 | 2.02427 | L_Aussenluft | 12.9553 | 5.83189 | 128 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 600 | 450 | 100 | 90 | 2.02427 | L_Aussenluft | 12.9553 | 5.83189 | 130 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 450 | 600 | 100 | 90 | 2.51907 | L_Aussenluft | 16.1221 | 4.22716 | 137 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 450 | 600 | 100 | 90 | 2.51907 | L_Aussenluft | 16.1221 | 4.22716 | 144 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 450 | 600 | 100 | 90 | 2.51907 | L_Fortluft | 16.1221 | 4.22716 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 450 | 600 | 100 | 90 | 2.57157 | L_Zuluft | 16.4581 | 4.22716 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 450 | 600 | 100 | 90 | 2.51907 | L_Abluft | 16.1221 | 4.22716 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 500 | 600 | 100 | 90 | 2.63903 | L_Zuluft | 16.8898 | 4.02895 | 182 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 500 | 600 | 100 | 90 | 2.63903 | L_Abluft | 16.8898 | 5.13657 | 184 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 918 | 612 | 100 | 45 | 2.01716 | L_Aussenluft | 12.9098 | 1.5442 | 566 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 918 | 612 | 100 | 45 | 2.01716 | L_Aussenluft | 12.9098 | 1.5442 | 568 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 918 | 612 | 100 | 45 | 2.01716 | L_Abluft | 12.9098 | 1.93336 | 34 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 2 | 918 | 612 | 100 | 45 | 2.01716 | L_Abluft | 12.9098 | 1.93336 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 600 | 500 | 100 | 90 | 2.29345 | L_Aussenluft | 14.6781 | 6.41954 | 573 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 600 | 500 | 100 | 90 | 2.29345 | L_Aussenluft | 14.6781 | 6.41954 | 576 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 500 | 600 | 100 | 90 | 2.63903 | L_Aussenluft | 16.8898 | 5.16159 | 586 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 500 | 600 | 100 | 90 | 2.63903 | L_Aussenluft | 16.8898 | 5.16159 | 597 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 600 | 500 | 100 | 45 | 1.25673 | L_Aussenluft | 8.04304 | 4.20099 | 593 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 193 | 2448 | 2448 | 100 | 45 | 20.5749 | L_Aussenluft | 181.059 | 1.92158 | 646 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 193 | 2448 | 2448 | 100 | 45 | 20.5749 | L_Aussenluft | 181.059 | 1.92158 | 649 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2448 | 2448 | 100 | 45 | 20.5749 | L_Abluft | 181.059 | 1.0212 | 5 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 1 | 2448 | 2448 | 100 | 45 | 20.5749 | L_Abluft | 181.059 | 1.0212 | 2 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 4 | 1200 | 2000 | 100 | 90 | 21.7515 | L_Abluft | 174.012 | 5.42411 | 57 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 82 | 300 | 350 | 100 | 90 | 1.04892 | L_Zuluft | 5.0348 | 3.1267 | 446 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 115 | 350 | 350 | 100 | 90 | 1.1296 | L_Zuluft | 5.42209 | 3.99187 | 232 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 600 | 450 | 100 | 30 | 1 | L_Aussenluft | 5.21444 | 3.05713 | 154 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 17 | 600 | 450 | 100 | 30 | 1 | L_Aussenluft | 5.21444 | 3.05713 | 152 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 600 | 500 | 100 | 30 | 1 | L_Aussenluft | 5.83136 | 3.36903 | 606 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Bogen symmetrisch | Wartung_FFB | 53 | 600 | 500 | 100 | 30 | 1 | L_Aussenluft | 5.83136 | 3.36903 | 604 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
