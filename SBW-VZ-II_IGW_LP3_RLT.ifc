Properties of the parts of a building model (IFC2X3), part 9 of 18

# IfcFlowSegment: Luftleitung (1382)
Name | In | Section No | Geom-Side 1 (mm) (mm) | Geom-Side 2 (mm) (mm) | Geom-Length (mm) (mm) | Geom-Surface (m2) (m2) | Tech-Medium | Tech-Weight (kg) (kg) | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 404 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 3 | 600 | 700 | 1500 | 3.9 | L_Abluft | 24.96 | 5810 | 3.84259 | 0.365316 | 405 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 600 | 700 | 1000 | 2.6 | L_Zuluft | 16.64 | 5740 | 3.7963 | 0.238113 | 374 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 800 | 1500 | 1280.61 | 5.89082 | L_Zuluft | 47.1265 | 16450 | 3.80787 | 0.171685 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1000 | 1200 | 1014.47 | 4.46367 | L_Abluft | 35.7094 | 16400 | 3.7963 | 0.128183 | 118 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 657 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 658 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 659 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 660 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 661 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 662 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 663 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 664 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 665 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 666 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 667 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 668 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 669 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 670 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 2200 | 1400 | 1226.7 | 8.83223 | L_Aussenluft | 77.7236 | 45900 | 4.13961 | 0.10618 | 671 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 1400 | 2200 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 673 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 1400 | 2200 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 676 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 1400 | 2200 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 677 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 1400 | 2200 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 678 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 1400 | 2200 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 679 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 193 | 1400 | 2200 | 1500 | 10.8 | L_Aussenluft | 95.04 | 45900 | 4.13961 | 0.129836 | 680 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 109 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7550 | 5.24306 | 0.69277 | 135 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 109 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7550 | 5.24306 | 0.69277 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 108 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7875 | 5.46875 | 0.749821 | 123 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 108 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7875 | 5.46875 | 0.749821 | 122 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 108 | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 7875 | 5.46875 | 0.749821 | 121 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 108 | 500 | 800 | 1200 | 3.12 | L_Zuluft | 19.968 | 7875 | 5.46875 | 0.599857 | 120 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1000 | 7.2 | L_Fortluft | 63.36 | 41900 | 3.77886 | 0.0729867 | 541 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 532 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 533 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 534 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 535 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 536 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 537 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 1400 | 2200 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 544 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 1400 | 2200 | 1167.15 | 8.40345 | L_Fortluft | 73.9504 | 41900 | 3.77886 | 0.0851862 | 545 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 911.546 | 6.56313 | L_Fortluft | 57.7555 | 41900 | 3.77886 | 0.0665308 | 547 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 552 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 551 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1500 | 10.8 | L_Fortluft | 95.04 | 41900 | 3.77886 | 0.10948 | 550 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 81 | 2200 | 1400 | 1008.81 | 7.26345 | L_Fortluft | 63.9184 | 41900 | 3.77886 | 0.07363 | 549 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 450 | 600 | 1307.4 | 2.74554 | L_Fortluft | 17.5715 | 3520 | 3.6214 | 0.376614 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 600 | 450 | 1500 | 3.15 | L_Fortluft | 20.16 | 3520 | 3.6214 | 0.432095 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 117 | 300 | 250 | 1064.46 | 1.17091 | L_Zuluft | 5.62035 | 975 | 3.61111 | 0.66507 | 265 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 117 | 300 | 250 | 1500 | 1.65 | L_Zuluft | 7.92 | 975 | 3.61111 | 0.937193 | 268 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 117 | 300 | 250 | 1201.91 | 1.3221 | L_Zuluft | 6.34606 | 975 | 3.61111 | 0.750945 | 267 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 115 | 350 | 350 | 1023.04 | 1.43225 | L_Zuluft | 6.87482 | 1625 | 3.68481 | 0.487782 | 235 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 115 | 350 | 350 | 924.314 | 1.29404 | L_Zuluft | 6.21139 | 1625 | 3.68481 | 0.44071 | 233 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 9 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1000 | 3.6 | L_Zuluft | 23.04 | 10120 | 3.47051 | 0.134857 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Zuluft | 34.56 | 10120 | 3.47051 | 0.202285 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1200 | 4.32 | L_Zuluft | 27.648 | 10120 | 3.47051 | 0.161828 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1442.81 | 5.19413 | L_Abluft | 33.2424 | 10190 | 3.49451 | 0.197082 | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 44 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 42 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 900 | 900 | 1500 | 5.4 | L_Abluft | 34.56 | 10190 | 3.49451 | 0.204894 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 600 | 1000 | 1133.13 | 3.62603 | L_Abluft | 23.2066 | 8200 | 3.7963 | 0.225163 | 79 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 600 | 1000 | 1124.71 | 3.59907 | L_Abluft | 23.0341 | 8200 | 3.7963 | 0.223489 | 76 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 600 | 1000 | 1000 | 3.2 | L_Abluft | 20.48 | 8200 | 3.7963 | 0.198708 | 72 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Zuluft | 14.4 | 3300 | 3.66667 | 0.457651 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1000 | 2 | L_Zuluft | 9.6 | 3300 | 3.66667 | 0.305101 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1000 | 1200 | 1195.14 | 5.2586 | L_Abluft | 42.0688 | 16400 | 3.7963 | 0.15101 | 115 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 800 | 1431.2 | 6.58351 | L_Zuluft | 52.6681 | 16450 | 3.80787 | 0.191874 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Zuluft | 14.4 | 3300 | 3.66667 | 0.457651 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 316 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 315 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 314 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 313 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 312 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 311 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 304 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 303 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 302 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 301 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 300 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 299 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 298 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 297 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 296 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 295 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 294 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 293 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 292 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 291 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 463 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 462 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 461 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 460 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 459 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 458 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 452 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 451 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 450 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 449 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 448 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 447 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 446 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 445 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 444 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 443 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 442 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 441 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 440 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 439 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 438 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1227 | 2.94481 | L_Zuluft | 18.8468 | 4720 | 3.74603 | 0.322784 | 310 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 305 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1421.44 | 3.41146 | L_Zuluft | 21.8333 | 4720 | 3.74603 | 0.373934 | 306 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1418.44 | 3.40426 | L_Abluft | 21.7872 | 4961 | 3.9373 | 0.409353 | 453 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1227 | 2.94481 | L_Abluft | 18.8468 | 4961 | 3.9373 | 0.354106 | 457 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 77 | 300 | 500 | 1500 | 2.4 | L_Abluft | 11.52 | 2000 | 3.7037 | 0.663286 | 58 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 69 | 800 | 500 | 1500 | 3.9 | L_Abluft | 24.96 | 5400 | 3.75 | 0.370454 | 93 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 800 | 500 | 1500 | 3.9 | L_Abluft | 24.96 | 5400 | 3.75 | 0.370454 | 191 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 18 | 500 | 350 | 1307.46 | 2.22269 | L_Zuluft | 10.6689 | 2202 | 3.49524 | 0.463 | 536 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 597 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 596 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1332.46 | 1.7322 | L_Zuluft | 8.31456 | 1350 | 3.57143 | 0.661722 | 600 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 595 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 594 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 33 | 1400 | 1300 | 1500 | 8.1 | L_Zuluft | 64.8 | 20909 | 3.19124 | 0.10634 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 2000 | 1800 | 1400 | 10.64 | L_Zuluft | 85.12 | 35186 | 2.71497 | 0.048881 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 33 | 1300 | 1400 | 948.838 | 5.12372 | L_Zuluft | 40.9898 | 20909 | 3.19124 | 0.0672661 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 37 | 1000 | 800 | 1500 | 5.4 | L_Zuluft | 34.56 | 10094 | 3.50486 | 0.209141 | 339 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1500 | 3.6 | L_Abluft | 23.04 | 4961 | 3.9373 | 0.43289 | 437 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 700 | 500 | 1500 | 3.6 | L_Zuluft | 23.04 | 4720 | 3.74603 | 0.3946 | 290 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1200 | 1000 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 518 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 61 | 700 | 400 | 1068.06 | 2.34974 | L_Abluft | 15.0383 | 3600 | 3.57143 | 0.303582 | 135 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 61 | 400 | 700 | 1234.54 | 2.716 | L_Abluft | 17.3824 | 3600 | 3.57143 | 0.350902 | 139 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 61 | 700 | 400 | 1500 | 3.3 | L_Abluft | 21.12 | 3600 | 3.57143 | 0.426354 | 144 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 69 | 500 | 800 | 1500 | 3.9 | L_Abluft | 24.96 | 5400 | 3.75 | 0.370454 | 87 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 69 | 500 | 800 | 1500 | 3.9 | L_Abluft | 24.96 | 5400 | 3.75 | 0.370454 | 86 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 69 | 800 | 500 | 922.633 | 2.39885 | L_Abluft | 15.3526 | 5400 | 3.75 | 0.227862 | 81 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 800 | 500 | 1500 | 3.9 | L_Abluft | 24.96 | 5400 | 3.75 | 0.370454 | 190 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 37 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1044.37 | 7.10169 | L_Abluft | 56.8135 | 31461 | 3.03443 | 0.0512572 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 31 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 29 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 33461 | 3.22733 | 0.0825597 | 25 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 33461 | 3.22733 | 0.0825597 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1425.34 | 9.69229 | L_Abluft | 77.5383 | 33461 | 3.22733 | 0.0784503 | 23 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 33461 | 3.22733 | 0.0825597 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 33461 | 3.22733 | 0.0825597 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 33461 | 3.22733 | 0.0825597 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1200 | 1000 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 517 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1109.98 | 1.44297 | L_Zuluft | 6.92628 | 1350 | 3.57143 | 0.551234 | 599 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 35 | 800 | 400 | 1500 | 3.6 | L_Abluft | 23.04 | 4500 | 3.90625 | 0.475759 | 315 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 35 | 800 | 400 | 1500 | 3.6 | L_Abluft | 23.04 | 4500 | 3.90625 | 0.475759 | 316 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 592 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 18 | 350 | 500 | 1186.91 | 2.01774 | L_Zuluft | 9.68516 | 2202 | 3.49524 | 0.420309 | 527 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 18 | 500 | 350 | 1500 | 2.55 | L_Zuluft | 12.24 | 2202 | 3.49524 | 0.531182 | 533 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 18 | 500 | 350 | 1500 | 2.55 | L_Zuluft | 12.24 | 2202 | 3.49524 | 0.531182 | 532 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 300 | 350 | 1000 | 1.3 | L_Zuluft | 6.24 | 1350 | 3.57143 | 0.496616 | 586 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 591 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 350 | 300 | 1500 | 1.95 | L_Zuluft | 9.36 | 1350 | 3.57143 | 0.744924 | 590 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 35 | 400 | 800 | 1500 | 3.6 | L_Abluft | 23.04 | 4500 | 3.90625 | 0.475759 | 309 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 550 | 300 | 1292.55 | 2.19734 | L_Abluft | 14.063 | 2200 | 3.7037 | 0.547718 | 279 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 300 | 550 | 1500 | 2.55 | L_Abluft | 16.32 | 2200 | 3.7037 | 0.635625 | 275 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 300 | 550 | 1123.3 | 1.90962 | L_Abluft | 12.2215 | 2200 | 3.7037 | 0.476 | 274 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 300 | 550 | 1500 | 2.55 | L_Abluft | 16.32 | 2200 | 3.7037 | 0.635625 | 272 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 300 | 350 | 1500 | 1.95 | L_Abluft | 9.36 | 1350 | 3.57143 | 0.744924 | 248 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1500 | 1.95 | L_Abluft | 9.36 | 1350 | 3.57143 | 0.744924 | 251 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1183.84 | 1.53899 | L_Abluft | 7.38716 | 1350 | 3.57143 | 0.587914 | 250 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 300 | 350 | 1439.65 | 1.87154 | L_Abluft | 8.98341 | 1350 | 3.57143 | 0.714953 | 247 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1000 | 1.3 | L_Abluft | 6.24 | 1350 | 3.57143 | 0.496616 | 245 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1500 | 1.95 | L_Abluft | 9.36 | 1350 | 3.57143 | 0.744924 | 240 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1240.26 | 1.61233 | L_Abluft | 7.7392 | 1350 | 3.57143 | 0.615931 | 239 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 47 | 350 | 300 | 1500 | 1.95 | L_Abluft | 9.36 | 1350 | 3.57143 | 0.744924 | 237 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1600 | 1800 | 1500 | 10.2 | L_Abluft | 81.6 | 31461 | 3.03443 | 0.0736196 | 33 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 53 | 500 | 800 | 1055.08 | 2.7432 | L_Abluft | 17.5565 | 5400 | 3.75 | 0.260571 | 183 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 61 | 400 | 700 | 976.489 | 2.14828 | L_Abluft | 13.749 | 3600 | 3.57143 | 0.277553 | 132 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 69 | 500 | 800 | 990.52 | 2.57535 | L_Abluft | 16.4822 | 5400 | 3.75 | 0.244628 | 79 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 35 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 12978 | 3.00417 | 0.122668 | 199 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 35 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 12978 | 3.00417 | 0.122668 | 198 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1200 | 1000 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 516 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1200 | 1000 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 515 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1200 | 1000 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 514 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 511 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 510 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 509 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 508 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 507 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 506 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 14277 | 3.30486 | 0.146425 | 505 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1500 | 5.4 | L_Fortluft | 34.56 | 10190 | 3.49451 | 0.204894 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 913.505 | 3.28862 | L_Aussenluft | 21.0472 | 10190 | 3.49451 | 0.124781 | 885 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 900 | 900 | 1219.68 | 4.39085 | L_Zuluft | 28.1014 | 10120 | 3.47051 | 0.164482 | 7 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 400 | 500 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 388 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 400 | 500 | 1500 | 2.7 | L_Fortluft | 12.96 | 2530 | 3.51389 | 0.488477 | 389 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 30 | 400 | 500 | 1499.74 | 2.69954 | L_Fortluft | 12.9578 | 2530 | 3.51389 | 0.488393 | 390 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1500 | 3 | L_Fortluft | 14.4 | 3300 | 3.66667 | 0.457651 | 27 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 500 | 500 | 1499.58 | 2.99915 | L_Fortluft | 14.3959 | 3300 | 3.66667 | 0.457522 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 35 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 39 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 40 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 42 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 400 | 500 | 1500 | 2.7 | L_Aussenluft | 12.96 | 2530 | 3.51389 | 0.488477 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1399.74 | 2.79949 | L_Aussenluft | 13.4375 | 3300 | 3.66667 | 0.427062 | 282 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 284 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 285 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 286 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 287 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 288 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1500 | 3 | L_Aussenluft | 14.4 | 3300 | 3.66667 | 0.457651 | 289 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 550 | 300 | 1410.8 | 2.39837 | L_Abluft | 15.3496 | 2200 | 3.7037 | 0.597829 | 284 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 550 | 300 | 1500 | 2.55 | L_Abluft | 16.32 | 2200 | 3.7037 | 0.635625 | 286 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 43 | 550 | 300 | 1208.84 | 2.05503 | L_Abluft | 13.1522 | 2200 | 3.7037 | 0.512246 | 287 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1000 | 2.4 | L_Abluft | 15.36 | 4961 | 3.9373 | 0.288594 | 466 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 700 | 500 | 1092.85 | 2.62283 | L_Abluft | 16.7861 | 4961 | 3.9373 | 0.315389 | 436 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 171 | 500 | 700 | 1000 | 2.4 | L_Zuluft | 15.36 | 4720 | 3.74603 | 0.263067 | 319 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 500 | 750 | 1354.22 | 3.38555 | L_Zuluft | 21.6675 | 5362.5 | 3.97222 | 0.383905 | 639 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 918.378 | 4.04086 | L_Zuluft | 32.3269 | 16525 | 4.37169 | 0.177405 | 79 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 902.958 | 3.97302 | L_Zuluft | 31.7841 | 16525 | 4.37169 | 0.174427 | 77 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 72 | 1500 | 700 | 1500 | 6.6 | L_Zuluft | 52.8 | 16525 | 4.37169 | 0.289759 | 89 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 73 | 700 | 800 | 1300.86 | 3.90259 | L_Zuluft | 24.9766 | 8000 | 3.96825 | 0.282244 | 315 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 106 | 600 | 800 | 1298.03 | 3.63448 | L_Zuluft | 23.2606 | 8525 | 4.93345 | 0.469032 | 92 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 4 | 1200 | 2000 | 1500 | 9.6 | L_Abluft | 76.8 | 32800 | 3.7963 | 0.129279 | 62 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1400 | 1500 | 1500 | 8.7 | L_Zuluft | 69.6 | 30925 | 4.09061 | 0.155023 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 1 | 1400 | 1500 | 1000 | 5.8 | L_Zuluft | 46.4 | 30925 | 4.09061 | 0.103349 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 49 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 20 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 10 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 12 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 10 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 10 | 800 | 1500 | 1500 | 6.9 | L_Zuluft | 55.2 | 16450 | 3.80787 | 0.201098 | 14 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 38 | 700 | 800 | 1135.44 | 3.40631 | L_Zuluft | 21.8004 | 8200 | 4.06746 | 0.257958 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 11 | 700 | 800 | 1000 | 3 | L_Zuluft | 19.2 | 8250 | 4.09226 | 0.229778 | 206 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 11 | 800 | 700 | 1500 | 4.5 | L_Zuluft | 28.8 | 8250 | 4.09226 | 0.344668 | 201 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 11 | 800 | 700 | 1000 | 3 | L_Zuluft | 19.2 | 8250 | 4.09226 | 0.229778 | 202 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 600 | 1000 | 1000 | 3.2 | L_Abluft | 20.48 | 8200 | 3.7963 | 0.198708 | 71 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 1200 | 500 | 1500 | 5.1 | L_Abluft | 40.8 | 8200 | 3.7963 | 0.320805 | 69 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 1200 | 500 | 1500 | 5.1 | L_Abluft | 40.8 | 8200 | 3.7963 | 0.320805 | 68 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 25 | 1200 | 500 | 1500 | 5.1 | L_Abluft | 40.8 | 8200 | 3.7963 | 0.320805 | 67 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1000 | 1200 | 1500 | 6.6 | L_Abluft | 52.8 | 16400 | 3.7963 | 0.189531 | 112 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1000 | 1200 | 1000 | 4.4 | L_Abluft | 35.2 | 16400 | 3.7963 | 0.126354 | 111 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1200 | 1000 | 1500 | 6.6 | L_Abluft | 52.8 | 16400 | 3.7963 | 0.189531 | 106 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1200 | 1000 | 1500 | 6.6 | L_Abluft | 52.8 | 16400 | 3.7963 | 0.189531 | 105 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1200 | 1000 | 1500 | 6.6 | L_Abluft | 52.8 | 16400 | 3.7963 | 0.189531 | 104 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1200 | 1000 | 1500 | 6.6 | L_Abluft | 52.8 | 16400 | 3.7963 | 0.189531 | 103 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 6 | 1200 | 1000 | 1000 | 4.4 | L_Abluft | 35.2 | 16400 | 3.7963 | 0.126354 | 102 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 1200 | 500 | 1500 | 5.1 | L_Abluft | 40.8 | 8200 | 3.7963 | 0.320805 | 135 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1000.84 | 3.20268 | L_Abluft | 20.4972 | 8200 | 3.7963 | 0.198875 | 133 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 137 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 138 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1500 | 4.8 | L_Abluft | 30.72 | 8200 | 3.7963 | 0.298062 | 139 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 600 | 1000 | 1099.16 | 3.51732 | L_Abluft | 22.5108 | 8200 | 3.7963 | 0.218413 | 140 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1500 | 1400 | 1322.49 | 7.67043 | L_Aussenluft | 61.3634 | 32600 | 4.31217 | 0.15086 | 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 8 | 1400 | 1500 | 1000 | 5.8 | L_Aussenluft | 46.4 | 32600 | 4.31217 | 0.114073 | 105 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 93 | 900 | 900 | 1000 | 3.6 | L_Aussenluft | 23.04 | 10190 | 3.49451 | 0.136596 | 892 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 2 | 500 | 500 | 1000 | 2 | L_Abluft | 9.6 | 3300 | 3.66667 | 0.305101 | 46 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 39 | 800 | 700 | 1500 | 4.5 | L_Zuluft | 28.8 | 7875 | 3.90625 | 0.31604 | 42 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 39 | 800 | 700 | 1274.55 | 3.82365 | L_Zuluft | 24.4714 | 7875 | 3.90625 | 0.268539 | 41 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 40 | 800 | 700 | 1500 | 4.5 | L_Zuluft | 28.8 | 7550 | 3.74504 | 0.29219 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 40 | 800 | 700 | 1500 | 4.5 | L_Zuluft | 28.8 | 7550 | 3.74504 | 0.29219 | 55 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 40 | 800 | 700 | 1243.17 | 3.7295 | L_Zuluft | 23.8688 | 7550 | 3.74504 | 0.242161 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 28 | 500 | 500 | 1015.25 | 2.0305 | L_Aussenluft | 9.74641 | 3300 | 3.66667 | 0.309754 | 294 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 7 | 300 | 350 | 1044.34 | 1.35764 | L_Zuluft | 6.51668 | 1350 | 3.57143 | 0.518636 | 587 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 17 | 600 | 450 | 1364.43 | 2.86531 | L_Aussenluft | 18.338 | 3520 | 3.6214 | 0.393043 | 129 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB | 5 | 500 | 750 | 1500 | 3.75 | L_Zuluft | 24 | 5362.5 | 3.97222 | 0.425232 | 633 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Luftleitung | Wartung_FFB |  | 1000 | 500 | 914.3 | 2.7429 | L_Zuluft | 17.5546 | 7237.5 | 4.02083 | 0.233261
Luftleitung | Wartung_FFB |  | 1000 | 600 | 914.3 | 2.92576 | L_Zuluft | 18.7249 | 8225 | 3.80787 | 0.182711
Luftleitung | Wartung_FFB |  | 1000 | 600 | 914.3 | 2.92576 | L_Zuluft | 18.7249
Luftleitung | Wartung_FFB |  | 800 | 1500 | 941.574 | 4.33124 | L_Zuluft | 34.6499
Luftleitung | Wartung_FFB |  | 1000 | 600 | 1000 | 3.2 | L_Zuluft | 20.48
Luftleitung | Wartung_FFB |  | 1500 | 1400 | 918.39 | 5.32666 | L_Aussenluft | 42.6133 | 32600 | 4.31217 | 0.104764
Luftleitung | Wartung_FFB |  | 1500 | 1400 | 918.39 | 5.32666 | L_Fortluft | 42.6133 | 32600 | 4.31217 | 0.104764
Luftleitung | Wartung_FFB |  | 1200 | 2000 | 1500 | 9.6 | L_Abluft | 76.8 | 32800 | 3.7963 | 0.129279
Luftleitung | Wartung_FFB |  | 1400 | 1500 | 1271.61 | 7.37534 | L_Zuluft | 59.0027 | 30925 | 4.09061 | 0.131419
Luftleitung | Wartung_FFB |  | 2200 | 1400 | 1061.13 | 7.64016 | L_Fortluft | 67.2334 | 41900 | 3.77886 | 0.0774487
Luftleitung | Wartung_FFB |  | 500 | 700 | 1500 | 3.6 | L_Zuluft | 23.04
Luftleitung | Wartung_FFB |  | 700 | 500 | 1017.85 | 2.44284 | L_Zuluft | 15.6342
Luftleitung | Wartung_FFB |  | 1000 | 600 | 1500 | 4.8 | L_Zuluft | 30.72 | 8225 | 3.80787 | 0.299756
Luftleitung | Wartung_FFB |  | 1500 | 800 | 1500 | 6.9 | L_Zuluft | 55.2
Luftleitung | Wartung_FFB |  | 1000 | 500 | 1000 | 3 | L_Zuluft | 19.2 | 7237.5 | 4.02083 | 0.255126
Luftleitung | Wartung_FFB |  | 1500 | 700 | 1000 | 4.4 | L_Zuluft | 35.2
Luftleitung | Wartung_FFB |  | 1500 | 500 | 966.954 | 3.86782 | L_Zuluft | 30.9425
Luftleitung | Wartung_FFB |  | 750 | 500 | 966.954 | 2.41739 | L_Zuluft | 15.4713 | 5362.5 | 3.97222 | 0.27412
Luftleitung | Wartung_FFB |  | 750 | 500 | 1188.23 | 2.97057 | L_Zuluft | 19.0116 | 5362.5 | 3.97222 | 0.336848
Luftleitung | Wartung_FFB |  | 500 | 500 | 1000 | 2 | L_Abluft | 9.6 | 3300 | 3.66667 | 0.305101
Luftleitung | Wartung_FFB |  | 500 | 800 | 1108.26 | 2.88148 | L_Abluft | 18.4415 | 5400 | 3.75 | 0.273707
2 x Luftleitung | Wartung_FFB |  | 450 | 800 | 1500 | 3.75 | L_Zuluft | 24 | 5047 | 3.89429 | 0.430717
Luftleitung | Wartung_FFB |  | 450 | 800 | 1158.15 | 2.89538 | L_Zuluft | 18.5304 | 5047 | 3.89429 | 0.332557
Luftleitung | Wartung_FFB |  | 450 | 800 | 925.244 | 2.31311 | L_Zuluft | 14.8039 | 5047 | 3.89429 | 0.265679
Luftleitung | Wartung_FFB |  | 800 | 450 | 1500 | 3.75 | L_Zuluft | 24 | 5047 | 3.89429 | 0.430717
Luftleitung | Wartung_FFB |  | 500 | 800 | 1500 | 3.9 | L_Zuluft | 24.96 | 5768 | 4.00556 | 0.418802
Luftleitung | Wartung_FFB |  | 500 | 800 | 908.152 | 2.36119 | L_Zuluft | 15.1116 | 5768 | 4.00556 | 0.253557
Luftleitung | Wartung_FFB |  | 500 | 400 | 1500 | 2.7 | L_Abluft | 12.96 | 2700 | 3.75 | 0.551073
Luftleitung | Wartung_FFB |  | 500 | 400 | 1173.77 | 2.11279 | L_Abluft | 10.1414 | 2700 | 3.75 | 0.431222
11 x Luftleitung | Wartung_FFB |  | 600 | 500 | 1500 | 3.3 | L_Zuluft | 21.12
8 x Luftleitung | Wartung_FFB |  | 600 | 500 | 1500 | 3.3 | L_Abluft | 21.12 | 4050 | 3.75 | 0.429072
Luftleitung | Wartung_FFB |  | 500 | 350 | 1500 | 2.55 | L_Zuluft | 12.24
Luftleitung | Wartung_FFB |  | 500 | 350 | 1173.77 | 1.99541 | L_Zuluft | 9.57797
Luftleitung | Wartung_FFB |  | 700 | 500 | 1092.85 | 2.62283 | L_Zuluft | 16.7861
Luftleitung | Wartung_FFB |  | 600 | 500 | 1000 | 2.2 | L_Zuluft | 14.08
2 x Luftleitung | Wartung_FFB |  | 500 | 600 | 1500 | 3.3 | L_Abluft | 21.12 | 4050 | 3.75 | 0.429072
Luftleitung | Wartung_FFB |  | 500 | 600 | 1489.84 | 3.27764 | L_Abluft | 20.9769 | 4050 | 3.75 | 0.426165
6 x Luftleitung | Wartung_FFB |  | 1200 | 500 | 1500 | 5.1 | L_Abluft | 40.8 | 9011 | 4.17176 | 0.382436
Luftleitung | Wartung_FFB |  | 500 | 600 | 1272.27 | 2.79899 | L_Abluft | 17.9135 | 4050 | 3.75 | 0.36393
Luftleitung | Wartung_FFB |  | 400 | 800 | 1376.14 | 3.30275 | L_Abluft | 21.1376 | 4500 | 3.90625 | 0.436475
Luftleitung | Wartung_FFB |  | 300 | 550 | 1357.99 | 2.30858 | L_Abluft | 14.7749 | 2200 | 3.7037 | 0.575446
Luftleitung | Wartung_FFB |  | 350 | 300 | 1366.03 | 1.77584 | L_Abluft | 8.52405 | 1350 | 3.57143 | 0.678394
6 x Luftleitung | Wartung_FFB |  | 1000 | 800 | 1500 | 5.4 | L_Zuluft | 34.56 | 10094 | 3.50486 | 0.209141
Luftleitung | Wartung_FFB |  | 1000 | 1200 | 1075 | 4.73 | L_Zuluft | 37.84 | 12978 | 3.00417 | 0.0879123
Luftleitung | Wartung_FFB |  | 1000 | 800 | 1000 | 3.6 | L_Zuluft | 23.04 | 10094 | 3.50486 | 0.139427
Luftleitung | Wartung_FFB |  | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 12978 | 3.00417 | 0.122668
Luftleitung | Wartung_FFB |  | 1000 | 1200 | 1500 | 6.6 | L_Zuluft | 52.8 | 15141 | 3.50486 | 0.163329
Luftleitung | Wartung_FFB |  | 350 | 450 | 1058.15 | 1.69304 | L_Zuluft | 8.12661 | 2163 | 3.81481 | 0.465529
Luftleitung | Wartung_FFB |  | 1000 | 1200 | 1441.42 | 6.34225 | L_Zuluft | 50.738 | 15141 | 3.50486 | 0.156951
2 x Luftleitung | Wartung_FFB |  | 1200 | 1000 | 1500 | 6.6 | L_Zuluft | 52.8 | 15141 | 3.50486 | 0.163329
Luftleitung | Wartung_FFB |  | 500 | 600 | 1155.08 | 2.54118 | L_Zuluft | 16.2636
Luftleitung | Wartung_FFB |  | 1500 | 500 | 1136.78 | 4.5471 | L_Zuluft | 36.3768
Luftleitung | Wartung_FFB |  | 500 | 400 | 1392 | 2.5056 | L_Abluft | 12.0269
Luftleitung | Wartung_FFB |  | 700 | 600 | 1450 | 3.77 | L_Zuluft | 24.128
Luftleitung | Wartung_FFB |  | 500 | 400 | 1215.31 | 2.18756 | L_Zuluft | 10.5003
3 x Luftleitung | Wartung_FFB |  | 400 | 500 | 1500 | 2.7 | L_Zuluft | 12.96
Luftleitung | Wartung_FFB |  | 400 | 500 | 1358.15 | 2.44467 | L_Zuluft | 11.7344
Luftleitung | EG_Verwaltung_FFB | 24 | 250 | 300 | 1500 | 1.65 | L_Zuluft | 7.92 | 990 | 3.66667 | 0.964031 | 653 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 250 | 300 | 1500 | 1.65 | L_Zuluft | 7.92 | 860 | 3.18519 | 0.743445 | 671 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 250 | 300 | 1157.9 | 1.27369 | L_Zuluft | 6.11371 | 860 | 3.18519 | 0.57389 | 672 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 26 | 250 | 200 | 1500 | 1.35 | L_Zuluft | 6.48 | 660 | 3.66667 | 1.24263 | 689 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 28 | 250 | 200 | 1500 | 1.35 | L_Abluft | 6.48 | 660 | 3.66667 | 1.24263 | 738 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 27 | 300 | 250 | 1500 | 1.65 | L_Abluft | 7.92 | 860 | 3.18519 | 0.743445 | 725 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 27 | 300 | 250 | 1000 | 1.1 | L_Abluft | 5.28 | 860 | 3.18519 | 0.49563 | 724 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 26 | 250 | 300 | 1500 | 1.65 | L_Abluft | 7.92 | 990 | 3.66667 | 0.964031 | 708 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 250 | 300 | 1315.55 | 1.44711 | L_Zuluft | 6.94612 | 860 | 3.18519 | 0.652028 | 669 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 27 | 250 | 300 | 1315.55 | 1.44711 | L_Abluft | 6.94612 | 860 | 3.18519 | 0.652028 | 721 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 25 | 300 | 300 | 1500 | 1.8 | L_Abluft | 8.64 | 1210 | 3.73457 | 0.886573 | 688 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 300 | 300 | 1500 | 1.8 | L_Zuluft | 8.64 | 1210 | 3.73457 | 0.886573 | 633 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 300 | 400 | 1500 | 2.1 | L_Abluft | 10.08 | 1540 | 3.56481 | 0.689965 | 655 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 22 | 300 | 400 | 1500 | 2.1 | L_Zuluft | 10.08 | 1540 | 3.56481 | 0.689965 | 605 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 300 | 300 | 1000 | 1.2 | L_Zuluft | 5.76 | 1210 | 3.73457 | 0.591049 | 631 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 23 | 350 | 400 | 1500 | 2.25 | L_Abluft | 10.8 | 1900 | 3.76984 | 0.689147 | 620 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 20 | 400 | 400 | 1500 | 2.4 | L_Zuluft | 11.52 | 2015 | 3.49826 | 0.551277 | 570 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 24 | 400 | 300 | 1500 | 2.1 | L_Abluft | 10.08 | 1540 | 3.56481 | 0.689965 | 653 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 400 | 450 | 1450 | 2.465 | L_Zuluft | 11.832 | 2370 | 3.65741 | 0.558102 | 469 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 19 | 400 | 500 | 1500 | 2.7 | L_Abluft | 12.96 | 2570 | 3.56944 | 0.502882 | 456 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 17 | 400 | 500 | 1300 | 2.34 | L_Zuluft | 11.232 | 2570 | 3.56944 | 0.435831 | 434 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 77 | 250 | 400 | 1500 | 1.95 | L_Zuluft | 9.36 | 1310 | 3.63889 | 0.818995 | 216 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 68 | 250 | 400 | 1500 | 1.95 | L_Abluft | 9.36 | 1310 | 3.63889 | 0.818995 | 342 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 78 | 250 | 300 | 1500 | 1.65 | L_Zuluft | 7.92 | 870 | 3.22222 | 0.759447 | 232 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 69 | 250 | 300 | 1500 | 1.65 | L_Abluft | 7.92 | 870 | 3.22222 | 0.759447 | 359 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 78 | 250 | 300 | 1500 | 1.65 | L_Zuluft | 7.92 | 870 | 3.22222 | 0.759447 | 231 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 69 | 250 | 300 | 1500 | 1.65 | L_Abluft | 7.92 | 870 | 3.22222 | 0.759447 | 358 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 78 | 250 | 300 | 1500 | 1.65 | L_Zuluft | 7.92 | 870 | 3.22222 | 0.759447 | 230 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 69 | 250 | 300 | 1500 | 1.65 | L_Abluft | 7.92 | 870 | 3.22222 | 0.759447 | 357 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 69 | 250 | 300 | 1304.23 | 1.43466 | L_Abluft | 6.88635 | 870 | 3.22222 | 0.660331 | 356 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 76 | 300 | 450 | 1500 | 2.25 | L_Zuluft | 10.8 | 1700 | 3.49794 | 0.627381 | 184 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 67 | 300 | 450 | 1500 | 2.25 | L_Abluft | 10.8 | 1700 | 3.49794 | 0.627381 | 310 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 77 | 400 | 250 | 1175.2 | 1.52776 | L_Zuluft | 7.33325 | 1310 | 3.63889 | 0.641656 | 215 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 76 | 300 | 450 | 1500 | 2.25 | L_Zuluft | 10.8 | 1700 | 3.49794 | 0.627381 | 183 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 76 | 300 | 450 | 1500 | 2.25 | L_Zuluft | 10.8 | 1700 | 3.49794 | 0.627381 | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 67 | 300 | 450 | 1500 | 2.25 | L_Abluft | 10.8 | 1700 | 3.49794 | 0.627381 | 309 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 67 | 300 | 450 | 1500 | 2.25 | L_Abluft | 10.8 | 1700 | 3.49794 | 0.627381 | 308 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 75 | 400 | 450 | 1500 | 2.55 | L_Zuluft | 12.24 | 2270 | 3.50309 | 0.515257 | 153 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 66 | 400 | 450 | 1500 | 2.55 | L_Abluft | 12.24 | 2270 | 3.50309 | 0.515257 | 279 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 76 | 300 | 450 | 1000 | 1.5 | L_Zuluft | 7.2 | 1700 | 3.49794 | 0.418254 | 181 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Luftleitung | EG_Verwaltung_FFB | 67 | 300 | 450 | 1000 | 1.5 | L_Abluft | 7.2 | 1700 | 3.49794 | 0.418254 | 307 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
