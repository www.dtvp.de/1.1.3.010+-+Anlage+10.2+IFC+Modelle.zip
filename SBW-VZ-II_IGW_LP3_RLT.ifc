Properties of the parts of a building model (IFC2X3), part 13 of 18

# IfcFlowSegment: Stutzen rund (240)
Name | In | Section No | Geom-Diameter (mm) (mm) | Tech-Medium | Pos. No. | Floor | Floor No. | Building = Building No.
Stutzen rund | EG_Verwaltung_FFB | 35 | 140 | L_Zuluft | 673 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 36 | 140 | L_Abluft | 739 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 35 | 125 | L_Abluft | 751 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 37 | 140 | L_Abluft | 726 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 38 | 125 | L_Abluft | 709 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 39 | 160 | L_Abluft | 689 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 37 | 160 | L_Zuluft | 634 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 40 | 100 | L_Abluft | 673 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 41 | 160 | L_Abluft | 656 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 38 | 100 | L_Zuluft | 616 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 39 | 160 | L_Zuluft | 606 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 42 | 160 | L_Abluft | 635 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 43 | 125 | L_Abluft | 621 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 41 | 160 | L_Zuluft | 583 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 42 | 125 | L_Zuluft | 571 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 43 | 180 | L_Zuluft | 470 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 55 | 100 | L_Abluft | 469 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 56 | 125 | L_Abluft | 457 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 53 | 125 | L_Zuluft | 435 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 81 | 200 | L_Zuluft | 217 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 72 | 200 | L_Abluft | 343 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 80 | 200 | L_Zuluft | 233 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 71 | 200 | L_Abluft | 360 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 82 | 160 | L_Zuluft | 199 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 83 | 125 | L_Zuluft | 185 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 73 | 125 | L_Abluft | 326 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 74 | 160 | L_Abluft | 311 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 84 | 160 | L_Zuluft | 169 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 85 | 180 | L_Zuluft | 154 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 75 | 160 | L_Abluft | 295 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 76 | 180 | L_Abluft | 280 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 86 | 140 | L_Zuluft | 134 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 87 | 140 | L_Zuluft | 121 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 77 | 140 | L_Abluft | 260 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 78 | 140 | L_Abluft | 247 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 88 | 140 | L_Zuluft | 103 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 89 | 125 | L_Zuluft | 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 79 | 140 | L_Abluft | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 80 | 125 | L_Abluft | 215 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 90 | 125 | L_Zuluft | 69 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 81 | 125 | L_Abluft | 198 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 91 | 160 | L_Zuluft | 55 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 92 | 160 | L_Zuluft | 42 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 82 | 160 | L_Abluft | 184 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 83 | 160 | L_Abluft | 169 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 69 | 160 | L_Zuluft | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 70 | 160 | L_Zuluft | 264 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 92 | 160 | L_Abluft | 78 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 93 | 160 | L_Abluft | 67 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 13 | 140 | L_Zuluft | 809 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 14 | 200 | L_Abluft | 834 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 15 | 200 | L_Abluft | 824 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 13 | 140 | L_Abluft | 847 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 57 | 200 | L_Abluft | 439 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 58 | 200 | L_Abluft | 430 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 59 | 200 | L_Abluft | 417 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 15 | 200 | L_Zuluft | 778 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 16 | 200 | L_Zuluft | 770 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 34 | 140 | L_Zuluft | 691 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 33 | 125 | L_Zuluft | 707 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 40 | 125 | L_Zuluft | 594 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 24 | 140 | L_Abluft | 526 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 14 | 140 | L_Zuluft | 526 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 25 | 140 | L_Abluft | 493 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 26 | 140 | L_Abluft | 475 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 15 | 140 | L_Zuluft | 495 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 20 | 140 | L_Zuluft | 440 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 30 | 200 | L_Abluft | 415 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 21 | 200 | L_Zuluft | 413 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 31 | 125 | L_Abluft | 392 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB |  | 125 | L_Zuluft |  | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 12 | 125 | L_Abluft | 576 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 16 | 200 | L_Abluft | 47 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 15 | 200 | L_Abluft | 61 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 14 | 200 | L_Abluft | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 15 | 200 | L_Zuluft | 25 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 14 | 200 | L_Zuluft | 41 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 12 | 200 | L_Zuluft | 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 11 | 200 | L_Zuluft | 85 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 10 | 200 | L_Zuluft | 96 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 12 | 200 | L_Abluft | 102 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 13 | 200 | L_Abluft | 92 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 11 | 200 | L_Abluft | 118 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 10 | 200 | L_Abluft | 133 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 16 | 125 | L_Zuluft | 250 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 10 | 100 | L_Zuluft | 340 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 11 | 100 | L_Zuluft | 329 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 9 | 100 | L_Abluft | 320 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 10 | 100 | L_Abluft | 305 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 17 | 180 | L_Zuluft | 188 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 18 | 180 | L_Abluft | 151 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 17 | 125 | L_Abluft | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 29 | 160 | L_Abluft | 56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 28 | 160 | L_Abluft | 72 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 27 | 160 | L_Zuluft | 111 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 26 | 160 | L_Zuluft | 131 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 12 | 160 | L_Abluft | 252 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 11 | 160 | L_Zuluft | 197 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 12 | 160 | L_Zuluft | 182 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 14 | 160 | L_Abluft | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 13 | 100 | L_Abluft | 228 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 13 | 100 | L_Zuluft | 159 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 27 | 160 | L_Zuluft | 35 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 28 | 160 | L_Abluft | 81 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 49 | 140 | L_Abluft | 210 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 26 | 160 | L_Zuluft | 54 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 27 | 160 | L_Abluft | 103 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 21 | 160 | L_Zuluft | 113 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 24 | 160 | L_Abluft | 130 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 22 | 160 | L_Abluft | 156 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 23 | 160 | L_Abluft | 146 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 20 | 160 | L_Zuluft | 126 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 21 | 160 | L_Abluft | 173 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 44 | 180 | L_Abluft | 523 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 53 | 100 | L_Abluft | 503 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 54 | 100 | L_Abluft | 491 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 52 | 100 | L_Zuluft | 453 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 14 | 200 | L_Zuluft | 791 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 16 | 200 | L_Abluft | 811 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 7 | 160 | L_Abluft | 275 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 16 | 200 | L_Zuluft | 12 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 13 | 200 | L_Zuluft | 55 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 41 | 200 | L_Zuluft | 187 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 201 | 200 | L_Zuluft | 333 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 196 | 200 | L_Zuluft | 346 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 185 | 200 | L_Zuluft | 68 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
31 x Stutzen rund | EG_Verwaltung_FFB | 186 | 200 | L_Zuluft | 65 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 187 | 200 | L_Zuluft | 59 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stutzen rund | EG_Verwaltung_FFB | 188 | 200 | L_Zuluft | 56 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 171 | 200 | L_Zuluft | 101 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x Stutzen rund | EG_Verwaltung_FFB | 172 | 200 | L_Zuluft | 98 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 6 | 160 | L_Zuluft | 219 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 22 | 160 | L_Zuluft | 93 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 23 | 160 | L_Zuluft | 80 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 22 | 125 | L_Zuluft | 395 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 23 | 200 | L_Zuluft | 384 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 40 | 140 | L_Zuluft | 211 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 29 | 200 | L_Zuluft | 229 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
Stutzen rund | EG_Verwaltung_FFB | 32 | 200 | L_Abluft | 374 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x Stutzen rund | EG_Verwaltung_FFB |  | 280 | L_Zuluft
Stutzen rund | EG_Verwaltung_FFB |  | 280 | L_Abluft
10 x Stutzen rund | EG_Verwaltung_FFB |  | 200 | L_Zuluft
6 x Stutzen rund | EG_Verwaltung_FFB |  | 200 | L_Abluft

# IfcFlowSegment: Wickelfalzrohr (1462)
Description: Wickelfalzrohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Material (ID): 1; Name: Wickelfalzrohr; Abbreviation: R-R
Name | In | Section No | Geom-Diameter (mm) (mm) | Geom-Length (mm) (mm) | Tech-Medium | Calc-Vol. flow (m3/h) (m3/hour) | Calc-Velocity (m/s) (m/s) | Calc-Pressure loss (Pa) (Pa) | Pos. No. | Floor | Floor No. | Building = Building No.
Wickelfalzrohr | Wartung_FFB | 1 | 630 | 1000 | L_Abluft | 4000 | 3.5644 | 0.218417 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 85 | 160 | 6000 | L_Zuluft | 325 | 4.49005 | 10.8921 | 479 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 85 | 160 | 2975.93 | L_Zuluft | 325 | 4.49005 | 5.40237 | 480 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 84 | 250 | 6000 | L_Zuluft | 650 | 3.67825 | 4.31982 | 470 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 84 | 250 | 4398.66 | L_Zuluft | 650 | 3.67825 | 3.1669 | 471 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 91 | 630 | 232.15 | L_Zuluft | 4300 | 3.83173 | 0.0579996 | 425 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 133 | 630 | 232.15 | L_Zuluft | 4300 | 3.83173 | 0.0579996 | 198 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 134 | 160 | 183.764 | L_Zuluft | 325 | 4.49005 | 0.333596 | 174 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 118 | 250 | 2367.96 | L_Zuluft | 650 | 3.67825 | 1.70486 | 282 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 118 | 250 | 1258.51 | L_Zuluft | 650 | 3.67825 | 0.906087 | 284 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 118 | 250 | 1787.55 | L_Zuluft | 650 | 3.67825 | 1.28698 | 286 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 119 | 160 | 3976.91 | L_Zuluft | 325 | 4.49005 | 7.21951 | 300 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 119 | 160 | 1116.57 | L_Zuluft | 325 | 4.49005 | 2.02697 | 302 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 85 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 484 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 85 | 160 | 833.019 | L_Zuluft | 325 | 4.49005 | 1.51223 | 482 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 86 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 475 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 86 | 160 | 818.019 | L_Zuluft | 325 | 4.49005 | 1.485 | 473 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 87 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 467 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 87 | 160 | 818.019 | L_Zuluft | 325 | 4.49005 | 1.485 | 465 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 88 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 454 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 88 | 160 | 793.019 | L_Zuluft | 325 | 4.49005 | 1.43961 | 452 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 143 | 160 | 939.601 | L_Zuluft | 325 | 4.49005 | 1.70571 | 103 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 142 | 160 | 939.601 | L_Zuluft | 325 | 4.49005 | 1.70571 | 117 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 123 | 160 | 934.839 | L_Zuluft | 325 | 4.49005 | 1.69707 | 271 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 121 | 160 | 970.289 | L_Zuluft | 325 | 4.49005 | 1.76142 | 288 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 119 | 160 | 102.029 | L_Zuluft | 325 | 4.49005 | 0.18522 | 306 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 194 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 177 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 185 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 166 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 160 | 818.019 | L_Zuluft | 325 | 4.49005 | 1.485 | 183 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 160 | 833.019 | L_Zuluft | 325 | 4.49005 | 1.51223 | 192 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 160 | 6000 | L_Zuluft | 325 | 4.49005 | 10.8921 | 189 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 160 | 2092.13 | L_Zuluft | 325 | 4.49005 | 3.79796 | 190 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 160 | 818.019 | L_Zuluft | 325 | 4.49005 | 1.485 | 175 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 250 | 6000 | L_Zuluft | 650 | 3.67825 | 4.31982 | 180 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 250 | 2522.7 | L_Zuluft | 650 | 3.67825 | 1.81627 | 181 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 160 | 793.019 | L_Zuluft | 325 | 4.49005 | 1.43961 | 164 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 91 | 630 | 592.854 | L_Zuluft | 4300 | 3.83173 | 0.148117 | 423 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 91 | 630 | 6000 | L_Zuluft | 4300 | 3.83173 | 1.49902 | 421 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 91 | 630 | 6000 | L_Zuluft | 4300 | 3.83173 | 1.49902 | 420 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 91 | 630 | 1621.18 | L_Zuluft | 4300 | 3.83173 | 0.405032 | 419 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 630 | 904.752 | L_Zuluft | 4300 | 3.83173 | 0.226041 | 136 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 630 | 6000 | L_Zuluft | 4300 | 3.83173 | 1.49902 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 630 | 6000 | L_Zuluft | 4300 | 3.83173 | 1.49902 | 133 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 630 | 3060.26 | L_Zuluft | 4300 | 3.83173 | 0.764567 | 132 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 160 | 378.452 | L_Zuluft | 325 | 4.49005 | 0.687025 | 148 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 160 | 274.138 | L_Zuluft | 325 | 4.49005 | 0.497659 | 150 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 160 | 696.676 | L_Zuluft | 325 | 4.49005 | 1.26471 | 122 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 59 | 160 | 696.676 | L_Zuluft | 325 | 4.49005 | 1.26471 | 107 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 61 | 160 | 696.676 | L_Zuluft | 325 | 4.49005 | 1.26471 | 93 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 31 | 630 | 6000 | L_Zuluft | 4300 | 3.83173 | 1.49902 | 267 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 31 | 630 | 6000 | L_Zuluft | 4300 | 3.83173 | 1.49902 | 266 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 37 | 160 | 1124.13 | L_Zuluft | 300 | 4.14466 | 1.75925 | 211 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 143 | 160 | 341.902 | L_Zuluft | 325 | 4.49005 | 0.620674 | 99 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 143 | 160 | 234.513 | L_Zuluft | 325 | 4.49005 | 0.425724 | 101 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 142 | 160 | 341.902 | L_Zuluft | 325 | 4.49005 | 0.620674 | 113 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 142 | 160 | 234.513 | L_Zuluft | 325 | 4.49005 | 0.425724 | 115 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 36 | 160 | 1124.13 | L_Zuluft | 300 | 4.14466 | 1.75925 | 220 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 29 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 297 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 30 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 282 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 32 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 260 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 33 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 251 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 34 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 238 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 35 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 229 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 27 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 324 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 28 | 160 | 1124.13 | L_Zuluft | 325 | 4.49005 | 2.0407 | 312 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 23 | 160 | 6000 | L_Zuluft | 375 | 5.18082 | 14.2158 | 340 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 23 | 160 | 820.628 | L_Zuluft | 375 | 5.18082 | 1.94431 | 341 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 28 | 160 | 793.019 | L_Zuluft | 325 | 4.49005 | 1.43961 | 310 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 29 | 160 | 296.569 | L_Zuluft | 325 | 4.49005 | 0.538378 | 293 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 29 | 160 | 307.039 | L_Zuluft | 325 | 4.49005 | 0.557385 | 295 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 30 | 160 | 261.213 | L_Zuluft | 325 | 4.49005 | 0.474195 | 278 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 30 | 160 | 332.039 | L_Zuluft | 325 | 4.49005 | 0.602768 | 280 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 31 | 630 | 3060.26 | L_Zuluft | 4300 | 3.83173 | 0.764567 | 265 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 32 | 160 | 473.019 | L_Zuluft | 325 | 4.49005 | 0.858697 | 258 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 33 | 160 | 473.019 | L_Zuluft | 325 | 4.49005 | 0.858697 | 249 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 34 | 160 | 373.019 | L_Zuluft | 325 | 4.49005 | 0.677162 | 236 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 35 | 160 | 373.019 | L_Zuluft | 325 | 4.49005 | 0.677162 | 227 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 36 | 160 | 373.019 | L_Zuluft | 300 | 4.14466 | 0.583769 | 218 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 37 | 160 | 373.019 | L_Zuluft | 300 | 4.14466 | 0.583769 | 209 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 69 | 160 | 5776.24 | L_Zuluft | 325 | 4.49005 | 10.4859 | 22 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 69 | 160 | 1106.66 | L_Zuluft | 325 | 4.49005 | 2.00899 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 25 | 160 | 1622.04 | L_Zuluft | 375 | 5.18082 | 3.84309 | 334 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 23 | 160 | 1637.04 | L_Zuluft | 375 | 5.18082 | 3.87863 | 345 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 119 | 160 | 3382.3 | L_Zuluft | 325 | 4.49005 | 6.14008 | 304 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 119 | 160 | 1626.48 | L_Zuluft | 325 | 4.49005 | 2.95264 | 310 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 119 | 160 | 557.936 | L_Zuluft | 325 | 4.49005 | 1.01285 | 308 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 121 | 160 | 1648.31 | L_Zuluft | 325 | 4.49005 | 2.99226 | 290 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 123 | 160 | 1683.75 | L_Zuluft | 325 | 4.49005 | 3.05662 | 273 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 129 | 160 | 287.741 | L_Zuluft | 325 | 4.49005 | 0.522352 | 224 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 129 | 160 | 468.492 | L_Zuluft | 325 | 4.49005 | 0.850481 | 222 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 129 | 160 | 1723.3 | L_Zuluft | 325 | 4.49005 | 3.12839 | 226 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 131 | 160 | 237.741 | L_Zuluft | 325 | 4.49005 | 0.431585 | 209 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 131 | 160 | 468.492 | L_Zuluft | 325 | 4.49005 | 0.850481 | 207 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 131 | 160 | 1723.31 | L_Zuluft | 325 | 4.49005 | 3.12841 | 211 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 134 | 160 | 589.364 | L_Zuluft | 325 | 4.49005 | 1.06991 | 176 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 134 | 160 | 102.675 | L_Zuluft | 325 | 4.49005 | 0.186391 | 178 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 134 | 160 | 1700.35 | L_Zuluft | 325 | 4.49005 | 3.08673 | 180 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 136 | 160 | 15 | L_Zuluft | 325 | 4.49005 | 0.0272303 | 158 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 136 | 160 | 300.994 | L_Zuluft | 325 | 4.49005 | 0.546412 | 160 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 136 | 160 | 757.983 | L_Zuluft | 325 | 4.49005 | 1.37601 | 162 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 138 | 160 | 751.335 | L_Zuluft | 325 | 4.49005 | 1.36394 | 140 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 138 | 160 | 1566.04 | L_Zuluft | 325 | 4.49005 | 2.84291 | 144 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 104 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 319 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 104 | 160 | 1366.04 | L_Zuluft | 300 | 4.14466 | 2.13783 | 323 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 102 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 334 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 102 | 160 | 1366.04 | L_Zuluft | 300 | 4.14466 | 2.13783 | 338 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 100 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 348 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 100 | 160 | 1366.04 | L_Zuluft | 300 | 4.14466 | 2.13783 | 352 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 98 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 365 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 98 | 160 | 1466.04 | L_Zuluft | 300 | 4.14466 | 2.29433 | 369 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 96 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 379 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 96 | 160 | 1466.04 | L_Zuluft | 300 | 4.14466 | 2.29433 | 383 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 94 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 394 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 94 | 160 | 1466.05 | L_Zuluft | 300 | 4.14466 | 2.29434 | 398 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 92 | 160 | 751.335 | L_Zuluft | 300 | 4.14466 | 1.17583 | 409 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 92 | 160 | 1566.04 | L_Zuluft | 300 | 4.14466 | 2.45083 | 413 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 89 | 160 | 433.111 | L_Zuluft | 300 | 4.14466 | 0.677814 | 435 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 89 | 160 | 235.488 | L_Zuluft | 300 | 4.14466 | 0.368536 | 437 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 89 | 160 | 1800.58 | L_Zuluft | 300 | 4.14466 | 2.81788 | 439 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 160 | 1800.57 | L_Zuluft | 325 | 4.49005 | 3.26867 | 152 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 160 | 1604.69 | L_Zuluft | 325 | 4.49005 | 2.91308 | 126 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 59 | 160 | 1504.69 | L_Zuluft | 325 | 4.49005 | 2.73154 | 111 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 61 | 160 | 1504.7 | L_Zuluft | 325 | 4.49005 | 2.73156 | 97 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 63 | 160 | 1504.7 | L_Zuluft | 325 | 4.49005 | 2.73156 | 82 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 69 | 160 | 1516.04 | L_Zuluft | 325 | 4.49005 | 2.75215 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 170 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 140 | 6000 | L_Abluft | 200 | 3.60896 | 8.59723 | 140 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 101.205 | L_Abluft | 100 | 3.53678 | 0.213625 | 144 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 191.263 | L_Abluft | 100 | 3.53678 | 0.403723 | 146 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 308.737 | L_Abluft | 100 | 3.53678 | 0.65169 | 148 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 769.238 | L_Abluft | 100 | 3.53678 | 1.62373 | 150 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 1994.15 | L_Abluft | 100 | 3.53678 | 4.2093 | 155 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 47 | 100 | 351.202 | L_Zuluft | 100 | 3.53678 | 0.741326 | 112 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 47 | 100 | 218.898 | L_Zuluft | 100 | 3.53678 | 0.462055 | 114 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 47 | 100 | 218.898 | L_Zuluft | 100 | 3.53678 | 0.462055 | 118 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 47 | 100 | 383.194 | L_Zuluft | 100 | 3.53678 | 0.808855 | 120 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 140.461 | L_Zuluft | 100 | 3.53678 | 0.296489 | 85 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 266.071 | L_Abluft | 100 | 3.53678 | 0.561629 | 117 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 190 | L_Abluft | 100 | 3.53678 | 0.401057 | 119 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 425.461 | L_Abluft | 100 | 3.53678 | 0.898074 | 121 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 109 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 108 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 6000 | L_Zuluft | 100 | 3.53678 | 12.665 | 79 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 6000 | L_Zuluft | 100 | 3.53678 | 12.665 | 78 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 2947.91 | L_Zuluft | 100 | 3.53678 | 6.22252 | 77 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 6000 | L_Zuluft | 100 | 3.53678 | 12.665 | 75 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 6000 | L_Zuluft | 100 | 3.53678 | 12.665 | 74 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 2947.91 | L_Abluft | 100 | 3.53678 | 6.22252 | 107 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 105 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 104 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 922.607 | L_Abluft | 100 | 3.53678 | 1.94746 | 103 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 100 | 101.205 | L_Abluft | 100 | 3.53678 | 0.213625 | 92 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 218.898 | L_Zuluft | 100 | 3.53678 | 0.462055 | 62 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 351.202 | L_Zuluft | 100 | 3.53678 | 0.741326 | 60 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 1873.28 | L_Zuluft | 100 | 3.53678 | 3.95417 | 73 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 309.109 | L_Zuluft | 100 | 3.53678 | 0.652475 | 66 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 230.15 | L_Zuluft | 100 | 3.53678 | 0.485808 | 68 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 1303.1 | L_Abluft | 100 | 3.53678 | 2.75063 | 102 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 100 | 922.281 | L_Abluft | 100 | 3.53678 | 1.94678 | 97 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 100 | 159.84 | L_Abluft | 100 | 3.53678 | 0.337395 | 94 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 2673.71 | L_Zuluft | 200 | 3.60896 | 3.83109 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 213.195 | L_Zuluft | 200 | 3.60896 | 0.305482 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 213.195 | L_Abluft | 200 | 3.60896 | 0.305482 | 86 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 2321.28 | L_Abluft | 200 | 3.60896 | 3.3261 | 88 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 140 | 3822.72 | L_Abluft | 200 | 3.60896 | 5.47747 | 127 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 140 | 6000 | L_Abluft | 200 | 3.60896 | 8.59723 | 130 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 140 | 3001.2 | L_Abluft | 200 | 3.60896 | 4.30034 | 129 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 6000 | L_Zuluft | 300 | 3.27479 | 5.24763 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 6000 | L_Abluft | 300 | 3.27479 | 5.24763 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 4042.72 | L_Abluft | 300 | 3.27479 | 3.53578 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 4921.72 | L_Zuluft | 300 | 3.27479 | 4.30456 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 1291.06 | L_Zuluft | 300 | 3.27479 | 1.12917 | 11 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 6000 | L_Zuluft | 300 | 3.27479 | 5.24763 | 17 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 6000 | L_Zuluft | 300 | 3.27479 | 5.24763 | 18 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 1291.06 | L_Abluft | 300 | 3.27479 | 1.12917 | 46 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 6000 | L_Abluft | 300 | 3.27479 | 5.24763 | 52 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 6000 | L_Abluft | 300 | 3.27479 | 5.24763 | 53 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 218.898 | L_Zuluft | 100 | 3.53678 | 0.462055 | 32 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 351.202 | L_Zuluft | 100 | 3.53678 | 0.741326 | 30 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 309.109 | L_Zuluft | 100 | 3.53678 | 0.652475 | 36 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 230.15 | L_Zuluft | 100 | 3.53678 | 0.485808 | 38 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 922.281 | L_Abluft | 100 | 3.53678 | 1.94678 | 70 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 159.84 | L_Abluft | 100 | 3.53678 | 0.337395 | 67 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 351.202 | L_Abluft | 100 | 3.53678 | 0.741326 | 65 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 1956.41 | L_Abluft | 200 | 3.60896 | 2.80329 | 75 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 1379.43 | L_Zuluft | 200 | 3.60896 | 1.97655 | 43 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 1795.5 | L_Zuluft | 300 | 3.27479 | 1.57035 | 19 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 1468.52 | L_Abluft | 300 | 3.27479 | 1.28437 | 54 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 1921.41 | L_Abluft | 100 | 3.53678 | 4.05577 | 61 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 59 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 1594.43 | L_Zuluft | 100 | 3.53678 | 3.36557 | 26 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 6000 | L_Zuluft | 100 | 3.53678 | 12.665 | 24 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 140 | 160 | 751.335 | L_Zuluft | 325 | 4.49005 | 1.36394 | 126 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 140 | 160 | 1566.04 | L_Zuluft | 325 | 4.49005 | 2.84291 | 130 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 133 | 630 | 376.853 | L_Zuluft | 4300 | 3.83173 | 0.0941519 | 192 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 133 | 630 | 3349.98 | L_Zuluft | 4300 | 3.83173 | 0.83695 | 190 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 133 | 630 | 376.808 | L_Zuluft | 4300 | 3.83173 | 0.0941406 | 188 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 133 | 630 | 5028.77 | L_Zuluft | 4300 | 3.83173 | 1.25637 | 186 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 127 | 160 | 1613.38 | L_Zuluft | 325 | 4.49005 | 2.92887 | 240 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 125 | 160 | 1638.38 | L_Zuluft | 325 | 4.49005 | 2.97425 | 255 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 6000 | L_Abluft | 200 | 3.60896 | 8.59723 | 79 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 6000 | L_Abluft | 200 | 3.60896 | 8.59723 | 78 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 6000 | L_Zuluft | 200 | 3.60896 | 8.59723 | 47 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 6000 | L_Zuluft | 200 | 3.60896 | 8.59723 | 46 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 2798.2 | L_Zuluft | 100 | 3.53678 | 5.90652 | 76 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 2798.2 | L_Abluft | 100 | 3.53678 | 5.90652 | 106 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 1009.11 | L_Abluft | 100 | 3.53678 | 2.13005 | 169 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 624.264 | L_Abluft | 100 | 3.53678 | 1.31771 | 167 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 6000 | L_Abluft | 100 | 3.53678 | 12.665 | 165 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 1786.49 | L_Abluft | 100 | 3.53678 | 3.77097 | 164 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 939.641 | L_Abluft | 100 | 3.53678 | 1.98342 | 162 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 2958.63 | L_Abluft | 100 | 3.53678 | 6.24514 | 160 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 1646.75 | L_Abluft | 100 | 3.53678 | 3.476 | 158 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 3551.24 | L_Abluft | 100 | 3.53678 | 7.49605 | 156 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 6000 | L_Zuluft | 630 | 3.56507 | 4.07738 | 136 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 140 | 5470.81 | L_Abluft | 200 | 3.60896 | 7.83896 | 139 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 5201.4 | L_Abluft | 200 | 3.60896 | 7.45294 | 84 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 5201.4 | L_Zuluft | 200 | 3.60896 | 7.45294 | 52 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 570.428 | L_Zuluft | 300 | 3.27479 | 0.498898 | 13 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 570.428 | L_Abluft | 300 | 3.27479 | 0.498898 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 1000 | L_Abluft | 300 | 3.27479 | 0.874604 | 50 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 53 | 180 | 5200.03 | L_Abluft | 300 | 3.27479 | 4.54797 | 51 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 1000 | L_Zuluft | 300 | 3.27479 | 0.874604 | 15 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 48 | 180 | 5200.03 | L_Zuluft | 300 | 3.27479 | 4.54797 | 16 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 289.187 | L_Zuluft | 100 | 3.53678 | 0.610424 | 21 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 289.187 | L_Abluft | 100 | 3.53678 | 0.610424 | 56 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 1009.23 | L_Abluft | 200 | 3.60896 | 1.4461 | 82 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 54 | 140 | 4236.13 | L_Abluft | 200 | 3.60896 | 6.06983 | 80 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 1009.23 | L_Zuluft | 200 | 3.60896 | 1.4461 | 50 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 49 | 140 | 4236.13 | L_Zuluft | 200 | 3.60896 | 6.06983 | 48 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 31 | 630 | 137.15 | L_Zuluft | 4300 | 3.83173 | 0.034265 | 271 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 630 | 137.15 | L_Zuluft | 4300 | 3.83173 | 0.034265 | 138 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 65 | 160 | 696.676 | L_Zuluft | 325 | 4.49005 | 1.26471 | 59 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 65 | 160 | 1254.69 | L_Zuluft | 325 | 4.49005 | 2.2777 | 63 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 63 | 160 | 696.676 | L_Zuluft | 325 | 4.49005 | 1.26471 | 78 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 67 | 160 | 696.676 | L_Zuluft | 325 | 4.49005 | 1.26471 | 45 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 67 | 160 | 1254.7 | L_Zuluft | 325 | 4.49005 | 2.27772 | 49 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 191.263 | L_Abluft | 100 | 3.53678 | 0.403723 | 177 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 308.737 | L_Abluft | 100 | 3.53678 | 0.65169 | 179 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 769.238 | L_Abluft | 100 | 3.53678 | 1.62373 | 181 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 46 | 100 | 218.898 | L_Zuluft | 100 | 3.53678 | 0.462055 | 143 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 46 | 100 | 218.898 | L_Zuluft | 100 | 3.53678 | 0.462055 | 147 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 46 | 100 | 383.194 | L_Zuluft | 100 | 3.53678 | 0.808855 | 149 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 101.205 | L_Abluft | 100 | 3.53678 | 0.213625 | 175 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 330.85 | L_Abluft | 100 | 3.53678 | 0.698367 | 171 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 3755.28 | L_Zuluft | 530 | 4.68623 | 5.58909 | 165 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 582.72 | L_Zuluft | 530 | 4.68623 | 0.867279 | 161 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 622.272 | L_Zuluft | 530 | 4.68623 | 0.926145 | 159 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 582.72 | L_Zuluft | 530 | 4.68623 | 0.867279 | 157 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 5771.94 | L_Zuluft | 530 | 4.68623 | 8.59055 | 163 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 6000 | L_Zuluft | 530 | 4.68623 | 8.92997 | 155 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 46 | 100 | 351.202 | L_Zuluft | 100 | 3.53678 | 0.741326 | 141 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 726.862 | L_Zuluft | 530 | 4.68623 | 1.08181 | 154 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 46 | 100 | 249.998 | L_Zuluft | 100 | 3.53678 | 0.527702 | 139 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 1697.39 | L_Zuluft | 630 | 3.56507 | 1.15348 | 137 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 500 | L_Zuluft | 630 | 3.56507 | 0.339782 | 134 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 6000 | L_Zuluft | 630 | 3.56507 | 4.07738 | 132 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 1533.59 | L_Zuluft | 630 | 3.56507 | 1.04217 | 131 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 815.377 | L_Zuluft | 630 | 3.56507 | 0.5541 | 129 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 2873.01 | L_Zuluft | 630 | 3.56507 | 1.95239 | 127 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 1522.48 | L_Zuluft | 630 | 3.56507 | 1.03462 | 125 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 304.998 | L_Abluft | 100 | 3.53678 | 0.643798 | 142 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 43 | 250 | 5338.68 | L_Zuluft | 630 | 3.56507 | 3.62797 | 123 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 47 | 100 | 249.998 | L_Zuluft | 100 | 3.53678 | 0.527702 | 110 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 42 | 250 | 6000 | L_Zuluft | 730 | 4.13095 | 5.35604 | 108 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 42 | 250 | 5770.26 | L_Zuluft | 730 | 4.13095 | 5.15096 | 107 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 42 | 250 | 6000 | L_Zuluft | 730 | 4.13095 | 5.35604 | 98 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 42 | 250 | 4481.72 | L_Zuluft | 730 | 4.13095 | 4.00071 | 95 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 42 | 250 | 2921.2 | L_Zuluft | 730 | 4.13095 | 2.60768 | 97 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 52 | 100 | 358.708 | L_Zuluft | 100 | 3.53678 | 0.75717 | 28 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 57 | 100 | 358.708 | L_Abluft | 100 | 3.53678 | 0.75717 | 63 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 56 | 100 | 304.998 | L_Abluft | 100 | 3.53678 | 0.643798 | 90 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 304.998 | L_Zuluft | 100 | 3.53678 | 0.643798 | 58 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 50 | 100 | 319.998 | L_Zuluft | 100 | 3.53678 | 0.67546 | 81 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 55 | 100 | 319.998 | L_Abluft | 100 | 3.53678 | 0.67546 | 111 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 1 | 630 | 3322.5 | L_Abluft | 5000 | 4.4555 | 1.09959 | 10 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 1 | 630 | 1504.85 | L_Abluft | 5000 | 4.4555 | 0.498034 | 8 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 1 | 400 | 500 | L_Abluft | 5000 | 11.0524 | 1.60292 | 2 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 1 | 630 | 393.279 | L_Abluft | 5000 | 4.4555 | 0.130157 | 6 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 2950 | L_Zuluft | 530 | 4.68623 | 4.39057 | 168 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 44 | 200 | 5600 | L_Zuluft | 530 | 4.68623 | 8.33464 | 166 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB | 51 | 100 | 319.998 | L_Abluft | 100 | 3.53678 | 0.67546 | 173 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB |  | 100 | 3062.03 | L_Zuluft | 100 | 3.53678 | 6.46342
Wickelfalzrohr | Wartung_FFB |  | 100 | 3118.41 | L_Abluft | 100 | 3.53678 | 6.58243
Wickelfalzrohr | Wartung_FFB |  | 140 | 5877.41 | L_Abluft | 200 | 3.60896 | 8.42157
Wickelfalzrohr | Wartung_FFB |  | 140 | 5581.36 | L_Zuluft | 200 | 3.60896 | 7.99737
Wickelfalzrohr | Wartung_FFB |  | 250 | 714.282 | L_Zuluft
Wickelfalzrohr | Wartung_FFB |  | 250 | 4759.73 | L_Zuluft
Wickelfalzrohr | Wartung_FFB |  | 160 | 568.019 | L_Zuluft
Wickelfalzrohr | Wartung_FFB | 1 | 400 | 500 | L_Abluft | 4000 | 8.84194 | 4.9588 | 2 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
Wickelfalzrohr | Wartung_FFB |  | 400 | 1053.79 | L_Abluft
Wickelfalzrohr | Wartung_FFB |  | 400 | 642.944 | L_Abluft
Wickelfalzrohr | Wartung_FFB |  | 630 | 316.431 | L_Zuluft
Wickelfalzrohr | Wartung_FFB |  | 250 | 296.655 | L_Zuluft
3 x Wickelfalzrohr | Wartung_FFB |  | 250 | 6000 | L_Zuluft
Wickelfalzrohr | Wartung_FFB |  | 140 | 421.155 | L_Abluft
3 x Wickelfalzrohr | Wartung_FFB |  | 140 | 6000 | L_Abluft
Wickelfalzrohr | Wartung_FFB |  | 250 | 3794.15 | L_Zuluft
Wickelfalzrohr | Wartung_FFB |  | 250 | 672.168 | L_Zuluft
Wickelfalzrohr | Wartung_FFB |  | 140 | 3509.02 | L_Abluft
Wickelfalzrohr | Wartung_FFB |  | 140 | 763.262 | L_Abluft
Wickelfalzrohr | EG_Verwaltung_FFB | 37 | 160 | 164.717 | L_Zuluft | 220 | 3.03942 | 0.14559 | 646 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
