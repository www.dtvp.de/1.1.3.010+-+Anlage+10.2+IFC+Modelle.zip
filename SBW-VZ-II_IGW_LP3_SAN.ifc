Properties of the parts of a building model (IFC2X3), part 9 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4208.46 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 401.099 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 55.8046 | 30 | 15 | 18 | 16 | 10.4626 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 101.115 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2528.5 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 953.394 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 142 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2131.44 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3546.29 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 350 | 30 | 12 | 15 | 13 | 2.5335 | 0.48129 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 53.9195 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2492 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 599.715 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3772.29 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5953.92 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 51 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1463.08 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 562.801 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1234.02 | 30 | 12 | 15 | 13 | 1.6875 | 0.38129 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 59.1692 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 204.169 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 236.587 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1358.37 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 154.557 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 20 | 22 | 19.6 | 18.8857 | 1.74003 | 0.525 | 0.63 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1596.06 | 10 | 20 | 22 | 19.6 | 18.8857 | 1.74003 | 0.525 | 0.63 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2530.17 | 10 | 20 | 22 | 19.6 | 18.8857 | 1.74003 | 0.525 | 0.63 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 194 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1450.4 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2892 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2892 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1069.5 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2821.4 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 526.461 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 196 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 168.464 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 58.6037 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2596 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 441.715 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1731.71 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4859.21 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 875.538 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2237.66 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2584 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 168.919 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 163.822 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 673.15 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 743.874 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1206.19 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 102 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0143357 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 69.699 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0143357 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 148.28 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 404.137 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1545.46 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2717.19 | 10 | 15 | 18 | 16 | 24.3213 | 1.74076 | 0.35 | 0.38 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1891.97 | 10 | 15 | 18 | 16 | 24.3213 | 1.74076 | 0.35 | 0.38 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2892 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 368.64 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3363.28 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 383.222 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1041.87 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.48 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 705.195 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.48 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 81 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.48 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 576.115 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2677.5 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 727.394 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 116 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2105.44 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3987.29 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 323 | 10 | 32 | 35 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2966.65 | 10 | 25 | 28 | 25.6 | 9.56443 | 1.42796 | 0.735 | 0.93 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 900.018 | 10 | 25 | 28 | 25.6 | 9.56443 | 1.42796 | 0.735 | 0.93 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 69.619 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0143357 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 305.822 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1235.46 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 915.345 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 996.725 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 96 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 91.9397 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2892 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1465.23 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 932.086 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 118.27 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5532.7 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 440.085 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2333.28 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1646.89 | 30 | 12 | 15 | 13 | 2.03555 | 0.424609 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 172.693 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 74.6934 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3084 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1378.24 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 620.502 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5968.27 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 96 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5953.7 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 666.088 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2029.28 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1795.89 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 201.438 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2884 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2635.4 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 284 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 692.562 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1637.89 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 119.554 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 301.511 | 30 | 15 | 18 | 16 | 2.80765 | 0.591857 | 0.119 | 0.17 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2684 | 30 | 15 | 18 | 16 | 2.80765 | 0.591857 | 0.119 | 0.17 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2610.49 | 30 | 15 | 18 | 16 | 2.80765 | 0.591857 | 0.119 | 0.17 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 951.17 | 30 | 15 | 18 | 16 | 2.80765 | 0.591857 | 0.119 | 0.17 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2575.27 | 30 | 15 | 18 | 16 | 2.80765 | 0.591857 | 0.119 | 0.17 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 204.341 | 30 | 15 | 18 | 16 | 2.80765 | 0.591857 | 0.119 | 0.17 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 52.061 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 89.7694 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 184.259 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3084 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 975.302 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1006.37 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 96 | 10 | 15 | 18 | 16 | 12.9957 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 8.79835 | 0.974824 | 0.196 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 89.7694 | 10 | 15 | 18 | 16 | 8.79835 | 0.974824 | 0.196 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1296.31 | 10 | 15 | 18 | 16 | 8.79835 | 0.974824 | 0.196 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 79.8912 | 10 | 15 | 18 | 16 | 8.79835 | 0.974824 | 0.196 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 432 | 10 | 15 | 18 | 16 | 8.79835 | 0.974824 | 0.196 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 432 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 79.8912 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 979 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2884 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1237.23 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 618.123 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 330.27 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 84 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2454.25 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1170.44 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 687.807 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 540.685 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 228.95 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2696 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 82.5248 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 113.91 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2236.89 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 284 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 674.501 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4511.29 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 594.517 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2120.85 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1726.89 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 17.0944 | 1.63631 | 0.329 | 0.47 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.111864 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4663.18 | 30 | 15 | 18 | 16 | 17.0944 | 1.63631 | 0.329 | 0.47 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.111864 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1067.46 | 30 | 15 | 18 | 16 | 17.0944 | 1.63631 | 0.329 | 0.47 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.111864 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 96 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2006.41 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2271.56 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3438.14 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 74 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4791.97 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4509.39 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 387.155 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2894 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 115.447 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 96.6304 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 407.869 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1639.02 | 10 | 80 | 88.9 | 84.9 | 2.9096 | 1.66662 | 9.435 | 12.63 | DN 80 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2450 | 10 | 80 | 88.9 | 84.9 | 2.9096 | 1.66662 | 9.435 | 12.63 | DN 80 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1180.87 | 10 | 80 | 88.9 | 84.9 | 2.9096 | 1.66662 | 9.435 | 12.63 | DN 80 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3788.41 | 10 | 80 | 88.9 | 84.9 | 2.9096 | 1.66662 | 9.435 | 12.63 | DN 80 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 707.352 | 10 | 80 | 88.9 | 84.9 | 2.9096 | 1.66662 | 9.435 | 12.63 | DN 80 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2440.41 | 10 | 80 | 88.9 | 84.9 | 2.9096 | 1.66662 | 9.435 | 12.63 | DN 80 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2545 | 20 | 80 | 88.9 | 84.9 | 3.89592 | 1.9602 | 11.097 | 14.292 | DN 80 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2003.09 | 20 | 80 | 88.9 | 84.9 | 3.89592 | 1.9602 | 11.097 | 14.292 | DN 80 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84aab50b-447d-4111-a846-616d3483bd11 | 39010 | 261.122
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2391 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2707.07 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3424.47 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2400 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1987.12 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
10 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 922.992 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3316.99 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 971.143 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2600 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 156.762 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1235.7 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5490.4 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1200 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 114.057 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 170.132 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5072.31 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 250 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1496.58 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 618.838 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1049.77 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2764.14 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 787.998 | 10 | 40 | 42 | 39 | 5.43429 | 1.39127 | 1.662 | 1.662 | DN 40 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2942 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 400.27 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 138 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2312.66 | 10 | 25 | 28 | 25.6 | 11.8851 | 1.61447 | 0.831 | 0.831 | DN 25 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2756.37 | 10 | 25 | 28 | 25.6 | 11.8851 | 1.61447 | 0.831 | 0.831 | DN 25 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 425.988 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 141 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2422.96 | 10 | 20 | 22 | 19.6 | 20.7696 | 1.83615 | 0.554 | 0.554 | DN 20 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 923.169 | 10 | 20 | 22 | 19.6 | 20.7696 | 1.83615 | 0.554 | 0.554 | DN 20 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3142 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
