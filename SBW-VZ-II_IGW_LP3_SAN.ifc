Properties of the parts of a building model (IFC2X3), part 10 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1380.77 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4300.99 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2892 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1600.4 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 184 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2520.17 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2885.6 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 169.117 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 667.73 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 131.122 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 500.965 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2043.73 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 10 | 15 | 18 | 16 | 16.117 | 1.37768 | 0.277 | 0.277 | DN 15 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2346 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0530563 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 191.811 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0530563 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | Grundleitungsebene | 1625 | 20 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 5577.3 | 20 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
2 x Systemrohr CrNiMo | Grundleitungsebene | 6000 | 20 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 1596.1 | 20 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 1124.09 | 20 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 2119.89 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 984.236 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 1675.53 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 6000 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 599.495 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 4201.17 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | Grundleitungsebene | 1140 | 0 | 100 | 108 | 104 |  |  |  |  | DN 100 6m | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123

# IfcFlowStorageDevice: Ladespeicher (2)
In: EG_Verwaltung_FFB
Description: Ladespeicher
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Ladespeicher; Info: 250 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowStorageDevice: Permeatbehälter (2)
In: EG_Verwaltung_FFB
Description: Permeatbehälter
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Permeatbehälter; Info: 2300 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 01 Handwaschbecken (16)
In: EG_Verwaltung_FFB
Description: 01 Handwaschbecken
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 400 mm; Geom-Depth (mm): 385 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 01 Handwaschbecken; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
01 Handwaschbecken | 28
01 Handwaschbecken | 35
01 Handwaschbecken | 56
01 Handwaschbecken | 37
01 Handwaschbecken | 79
01 Handwaschbecken | 13
01 Handwaschbecken | 72
01 Handwaschbecken | 96
01 Handwaschbecken | 45
01 Handwaschbecken | 89
01 Handwaschbecken | 47
01 Handwaschbecken | 61
01 Handwaschbecken | 86
01 Handwaschbecken | 65
01 Handwaschbecken | 58
01 Handwaschbecken | 30

# IfcFlowTerminal: 02 Schlauchaufroller (23)
In: EG_Verwaltung_FFB
Description: 02 Schlauchaufroller
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 115 m; Geom-Depth (mm): 414 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 2.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Permanent flow (Yes/No): no; Name: 02 Schlauchaufroller; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Relevant for piping calculation (Yes/No) | Pos. No.
02 Schlauchaufroller | yes | 77
02 Schlauchaufroller | no | 31
02 Schlauchaufroller | no | 55
02 Schlauchaufroller | no | 83
02 Schlauchaufroller | no | 36
02 Schlauchaufroller | no | 42
02 Schlauchaufroller | no | 17
02 Schlauchaufroller | no | 34
02 Schlauchaufroller | no | 60
02 Schlauchaufroller | no | 88
02 Schlauchaufroller | no | 78
02 Schlauchaufroller | no | 29
02 Schlauchaufroller | yes | 12
02 Schlauchaufroller | no | 46
02 Schlauchaufroller | no | 64
02 Schlauchaufroller | no | 85
02 Schlauchaufroller | no | 71
02 Schlauchaufroller | no | 97
02 Schlauchaufroller | no | 59
02 Schlauchaufroller | no | 48
02 Schlauchaufroller | no | 14
02 Schlauchaufroller | no | 92
02 Schlauchaufroller | yes | 76

# IfcFlowTerminal: 03 Ausgussbeckenkombination (5)
In: EG_Verwaltung_FFB
Description: 03 Ausgussbeckenkombination
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 500 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 2.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 03 Ausgussbeckenkombination; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Depth (mm) (mm) | Pos. No.
03 Ausgussbeckenkombination | 686 | 11
03 Ausgussbeckenkombination | 686 | 82
03 Ausgussbeckenkombination | 686 | 18
03 Ausgussbeckenkombination | 686 | 41
03 Ausgussbeckenkombination | 417 | 91

# IfcFlowTerminal: 04 Arbeitstisch mit Spülbecken (4)
In: EG_Verwaltung_FFB
Description: 04 Arbeitstisch mit Spülbecken
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1600 mm; Geom-Depth (mm): 654 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.25 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 04 Arbeitstisch mit Spülbecken; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
04 Arbeitstisch mit Spülbecken | 67
04 Arbeitstisch mit Spülbecken | 68
04 Arbeitstisch mit Spülbecken | 69
04 Arbeitstisch mit Spülbecken | 66

# IfcFlowTerminal: 05 Hygieneschleuse (3)
In: EG_Verwaltung_FFB
Description: 05 Hygieneschleuse
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Depth (mm): 820 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 05 Hygieneschleuse; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Pos. No.
05 Hygieneschleuse | 1600 | 39
05 Hygieneschleuse | 1700 | 16
05 Hygieneschleuse | 1600 | 40

# IfcFlowTerminal: 06 Hygienecenter
In: EG_Verwaltung_FFB
Description: 06 Hygienecenter
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 680 mm; Geom-Depth (mm): 442 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 06 Hygienecenter; Pos. No.: 87; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 07 Bodenwaage
In: EG_Verwaltung_FFB
Description: 07 Bodenwaage
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1000 mm; Geom-Depth (mm): 1250 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.25 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 07 Bodenwaage; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 11 Nassmüllaufgabestation (2)
In: EG_Verwaltung_FFB
Description: 11 Nassmüllaufgabestation
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 600 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.25 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 11 Nassmüllaufgabestation; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Depth (mm) (mm) | Pos. No.
11 Nassmüllaufgabestation | 700 | 27
11 Nassmüllaufgabestation | 750 | 63

# IfcFlowTerminal: 16 Rührwerkskessel ohne Kippfunktion 100l
In: EG_Verwaltung_FFB
Description: 16 Rührwerkskessel ohne Kippfunktion 100l
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 800 mm; Geom-Depth (mm): 800 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.15 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 16 Rührwerkskessel ohne Kippfunktion 100l; Pos. No.: 51; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 17 Elektrisches Multifunktionales Gargerät
In: EG_Verwaltung_FFB
Description: 17 Elektrisches Multifunktionales Gargerät
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1100 mm; Geom-Depth (mm): 906 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.15 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 17 Elektrisches Multifunktionales Gargerät; Pos. No.: 52; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 19 Heißluftdämpfer (2)
In: EG_Verwaltung_FFB
Description: 19 Heißluftdämpfer
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 850 mm; Geom-Depth (mm): 860 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.2 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 19 Heißluftdämpfer; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
19 Heißluftdämpfer | 53
19 Heißluftdämpfer | 54

# IfcFlowTerminal: 22 Kleinbeilagen
In: EG_Verwaltung_FFB
Description: 22 Kleinbeilagen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 400 mm; Geom-Depth (mm): 385 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 22 Kleinbeilagen; Pos. No.: 33; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 28 Putzmaschine (2)
In: EG_Verwaltung_FFB
Description: 28 Putzmaschine
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1500 mm; Geom-Depth (mm): 1700 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.25 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 28 Putzmaschine; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
28 Putzmaschine | 81
28 Putzmaschine | 43

# IfcFlowTerminal: 29 Reinigungsmatte
In: EG_Verwaltung_FFB
Description: 29 Reinigungsmatte
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1250 mm; Geom-Depth (mm): 1000 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 29 Reinigungsmatte; Pos. No.: 15; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 31 Geschirraufgabestation (2)
In: EG_Verwaltung_FFB
Description: 31 Geschirraufgabestation
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1500 mm; Geom-Depth (mm): 980 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.15 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 31 Geschirraufgabestation; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
31 Geschirraufgabestation | 26
31 Geschirraufgabestation | 25

# IfcFlowTerminal: 32 Spülmaschine Tablett Besteck (2)
In: EG_Verwaltung_FFB
Description: 32 Spülmaschine Tablett Besteck
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1600 mm; Geom-Depth (mm): 740 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 32 Spülmaschine Tablett Besteck; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Consumption (l/s) (m3/s) | Pos. No.
32 Spülmaschine Tablett Besteck | 0.277 | 6
32 Spülmaschine Tablett Besteck | 0.28 | 24

# IfcFlowTerminal: 33 Spülmaschine Teller (2)
In: EG_Verwaltung_FFB
Description: 33 Spülmaschine Teller
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1600 mm; Geom-Depth (mm): 1140 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 33 Spülmaschine Teller; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Consumption (l/s) (m3/s) | Pos. No.
33 Spülmaschine Teller | 0.277 | 5
33 Spülmaschine Teller | 0.28 | 23

# IfcFlowTerminal: 34 Spülmaschine Porzellan (2)
In: EG_Verwaltung_FFB
Description: 34 Spülmaschine Porzellan
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1600 mm; Geom-Depth (mm): 910 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 34 Spülmaschine Porzellan; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Consumption (l/s) (m3/s) | Pos. No.
34 Spülmaschine Porzellan | 0.277 | 4
34 Spülmaschine Porzellan | 0.28 | 22

# IfcFlowTerminal: 35 Spülmaschine Kunststoff (2)
In: EG_Verwaltung_FFB
Description: 35 Spülmaschine Kunststoff
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1600 mm; Geom-Depth (mm): 570 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 35 Spülmaschine Kunststoff; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Consumption (l/s) (m3/s) | Pos. No.
35 Spülmaschine Kunststoff | 0.277 | 3
35 Spülmaschine Kunststoff | 0.28 | 20

# IfcFlowTerminal: 36 Spülmaschine Besteck (2)
In: EG_Verwaltung_FFB
Description: 36 Spülmaschine Besteck
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 800 mm; Geom-Depth (mm): 815 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 36 Spülmaschine Besteck; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Consumption (l/s) (m3/s) | Pos. No.
36 Spülmaschine Besteck | 0.277 | 8
36 Spülmaschine Besteck | 0.28 | 73

# IfcFlowTerminal: 37 Spülmaschine Schwarzgeschirr
In: EG_Verwaltung_FFB
Description: 37 Spülmaschine Schwarzgeschirr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1600 mm; Geom-Depth (mm): 570 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.28 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 37 Spülmaschine Schwarzgeschirr; Pos. No.: 21; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 38 Wagenwaschanlage (2)
In: EG_Verwaltung_FFB
Description: 38 Wagenwaschanlage
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 2970 mm; Geom-Depth (mm): 3620 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: 38 Wagenwaschanlage; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Calc-Consumption (l/s) (m3/s) | Pos. No.
38 Wagenwaschanlage | 0.277 | 7
38 Wagenwaschanlage | 0.28 | 80

# IfcFlowTerminal: 39 Besteckvorreinigung
In: EG_Verwaltung_FFB
Description: 39 Besteckvorreinigung
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 800 mm; Geom-Depth (mm): 815 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 39 Besteckvorreinigung; Pos. No.: 74; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: 53 Arbeitszelle mit Waschbecken
In: EG_Verwaltung_FFB
Description: 53 Arbeitszelle mit Waschbecken
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 750 mm; Geom-Depth (mm): 700 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.1 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: 53 Arbeitszelle mit Waschbecken; Pos. No.: 50; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Ausgussbecken (4)
In: EG_Verwaltung_FFB
Description: Ausgussbecken
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 600 mm; Geom-Depth (mm): 500 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 2.5; Calc-Consumption (l/s): 0.07 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: Ausgussbecken; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
Ausgussbecken | 2
Ausgussbecken | 5
Ausgussbecken | 3
Ausgussbecken | 4

# IfcFlowTerminal: Druckentlastungsschacht
In: Grundleitungsebene
Description: Druckentlastungsschacht
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Druckentlastungsschacht; Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Duschwanne (11)
In: EG_Verwaltung_FFB
Description: Duschwanne
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1000 mm; Geom-Width (mm): 1000 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 2; Calc-Consumption (l/s): 0.15 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: Duschwanne; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
Duschwanne | 30
Duschwanne | 56
Duschwanne | 11
Duschwanne | 27
Duschwanne | 54
Duschwanne | 53
Duschwanne | 55
Duschwanne | 29
Duschwanne | 28
Duschwanne | 58
Duschwanne | 57

# IfcFlowTerminal: Fettabscheider
In: Grundleitungsebene
Description: Fettabscheider
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Fettabscheider; Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Geschirrspüler
In: EG_Verwaltung_FFB
Description: Geschirrspüler
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 600 mm; Geom-Width (mm): 600 mm; Geom-Height (mm): 900 mm; Calc-Coefficient: 1; Calc-Consumption (l/s): 0.07 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: Geschirrspüler; Pos. No.: 85; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Hebeanlage (fäk.)
In: Grundleitungsebene
Description: Hebeanlage (fäk.)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Hebeanlage (fäk.); Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Hebeanlage (fäk.-frei)
In: Grundleitungsebene
Description: Hebeanlage (fäk.-frei)
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Hebeanlage (fäk.-frei); Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: IfcObject (32)
In: EG_Verwaltung_FFB
Description: IfcObject
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: IfcObject

# IfcFlowTerminal: Lüftungsdecke - Ablaufpunkt (3)
In: EG_Verwaltung_FFB
Description: Lüftungsdecke - Ablaufpunkt
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 400 mm; Geom-Depth (mm): 400 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.25 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): yes; Name: Lüftungsdecke - Ablaufpunkt; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Probenahmeschacht
In: Grundleitungsebene
Description: Probenahmeschacht
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Probenahmeschacht; Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Schacht (3)
In: Grundleitungsebene
Description: Schacht
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Schacht; Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowTerminal: Spüle (2)
In: EG_Verwaltung_FFB
Description: Spüle
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 1200 m; Geom-Width (mm): 600 mm; Geom-Height (mm): 200 mm; Calc-Coefficient: 2.5; Calc-Consumption (l/s): 0.07 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: Spüle; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
Spüle | 35
Spüle | 33

# IfcFlowTerminal: Urinal (9)
In: EG_Verwaltung_FFB
Description: Urinal
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 325 mm; Geom-Width (mm): 365 mm; Geom-Height (mm): 300 mm; Calc-Coefficient: 0.5; Calc-Consumption (l/s): 0.15 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: Urinal; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Pos. No.
Urinal | 80
Urinal | 94
Urinal | 74
Urinal | 82
Urinal | 87
Urinal | 83
Urinal | 81
Urinal | 71
Urinal | 69

# IfcFlowTerminal: WC (19)
In: EG_Verwaltung_FFB
Description: WC
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 350 m; Geom-Width to wall side (mm): 300 mm; Geom-Height (mm): 340 mm; Calc-Coefficient: 0.5; Calc-Consumption (l/s): 0.13 m3/s; Calc-Flushing valve (yes/no): 0; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: WC; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Width (mm) (mm) | Pos. No.
WC | 540 | 98
WC | 540 | 96
2 x WC | 540 | 95
WC | 540 | 94
WC | 540 | 92
WC | 540 | 75
WC | 540 | 79
WC | 540 | 78
WC | 540 | 90
WC | 540 | 88
WC | 540 | 89
WC | 540 | 100
WC | 540 | 93
WC | 540 | 99
WC | 540 | 97
WC | 540 | 72
WC | 540 | 70
WC | 700 | 86

# IfcFlowTerminal: Waschtisch (34)
In: EG_Verwaltung_FFB
Description: Waschtisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Length (mm): 600 mm; Calc-Coefficient: 1.5; Calc-Consumption (l/s): 0.07 m3/s; Calc-Relevant for piping calculation (Yes/No): yes; Calc-Permanent flow (Yes/No): no; Name: Waschtisch; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Depth (mm) (mm) | Geom-Height (mm) (mm) | Pos. No.
Waschtisch | 500 | 200 | 48
Waschtisch | 500 | 200 | 25
Waschtisch | 500 | 200 | 45
Waschtisch | 500 | 200 | 44
Waschtisch | 500 | 200 | 43
Waschtisch | 500 | 200 | 22
Waschtisch | 500 | 200 | 42
Waschtisch | 500 | 200 | 23
Waschtisch | 500 | 200 | 41
Waschtisch | 500 | 200 | 40
Waschtisch | 500 | 200 | 39
Waschtisch | 500 | 200 | 18
Waschtisch | 500 | 200 | 32
Waschtisch | 500 | 200 | 47
Waschtisch | 500 | 200 | 46
Waschtisch | 500 | 200 | 12
Waschtisch | 500 | 200 | 93
Waschtisch | 500 | 200 | 17
Waschtisch | 500 | 200 | 13
Waschtisch | 500 | 200 | 20
Waschtisch | 500 | 200 | 21
Waschtisch | 500 | 200 | 19
Waschtisch | 500 | 200 | 52
Waschtisch | 560 | 200 | 15
Waschtisch | 500 | 200 | 51
Waschtisch | 500 | 200 | 49
Waschtisch | 500 | 200 | 38
Waschtisch | 500 | 200 | 26
Waschtisch | 500 | 200 | 36
Waschtisch | 500 | 200 | 24
Waschtisch | 500 | 200 | 50
Waschtisch | 500 | 200 | 8
Waschtisch | 500 | 200 | 9
Waschtisch | 560 | 160 | 34

# IfcProxy: Bodenwasserablauf DN 100 (40)
Description: Bodenwasserablauf DN 100; ProxyType: PRODUCT
Pset_MEP - Name: Bodenwasserablauf DN 100; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: Freier Auslauf Sprinklertank
Description: Freier Auslauf Sprinklertank; ProxyType: PRODUCT
Pset_MEP - Name: Freier Auslauf Sprinklertank; Pos. No.: 1; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: Hauptanschluss TW
Description: Hauptanschluss TW; ProxyType: PRODUCT
Pset_MEP - Name: Hauptanschluss TW; Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: enthärtetes Trinkwasser
Description: enthärtetes Trinkwasser; ProxyType: PRODUCT
Pset_MEP - Name: enthärtetes Trinkwasser; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: normales Trinkwasser
Description: normales Trinkwasser; ProxyType: PRODUCT
Pset_MEP - Name: normales Trinkwasser; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: zu Trinkwassernetz
Description: zu Trinkwassernetz; ProxyType: PRODUCT
Pset_MEP - Name: zu Trinkwassernetz; Pos. No.: 2; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcProxy: zu Weichwassernetz
Description: zu Weichwassernetz; ProxyType: PRODUCT
Pset_MEP - Name: zu Weichwassernetz; Pos. No.: 3; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
