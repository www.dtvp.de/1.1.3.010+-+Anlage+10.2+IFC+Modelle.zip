Properties of the parts of a building model (IFC2X3), part 6 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 231 | 10 | 40 | 42 | 39 | 2.21083 | 0.837107 | 1 | 1 | DN 40 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 685.645 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 13.09 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 25.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1402.95 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 25.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 217.553 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 25.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3551.3 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 25.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2828.99 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 25.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1150 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 25.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1150 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2828.99 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3475.54 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 217.553 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
11 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 803.714 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 824.036 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2270 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4825.2 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2390 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 615.132 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 544.559 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 924.544 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3686.95 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3307.67 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3863.01 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3119.38 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3015 | 10 | 100 | 108 | 104 | 1.19769 | 1.16541 | 9.9 | 26.18 | DN 100 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7c70f9bd-16d7-4e9f-8d18-bc2255b7ccfd | 39011 | 261.123
Systemrohr CrNiMo | EG_Verwaltung_FFB | 265.38 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 6.54263 | 1.31917 | 0.679 | 0.97 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.175747 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1867.67 | 40 | 25 | 28 | 25.6 | 6.54263 | 1.31917 | 0.679 | 0.97 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.175747 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4800.77 | 70 | 50 | 54 | 51 | 2.2932 | 1.17191 | 2.394 | 3.42 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.366749 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4747.78 | 10 | 65 | 76.1 | 72.1 | 1.49596 | 1.0287 | 4.2 | 5.76 | DN 65 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0c94a1d0-3d32-45b6-8dca-5e46eec327d7 | 39009 | 261.121
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 40 | 42 | 39 | 5.95636 | 1.46494 | 1.75 | 2.26 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1791.67 | 10 | 40 | 42 | 39 | 5.95636 | 1.46494 | 1.75 | 2.26 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 166.363 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 5.59123 | 0.874091 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.175747 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1875.67 | 30 | 15 | 18 | 16 | 5.59123 | 0.874091 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.175747 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4868.77 | 40 | 25 | 28 | 25.6 | 2.17782 | 0.712524 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.366749 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4245.47 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 20 | 22 | 19.6 | 20.1764 | 1.80632 | 0.545 | 0.65 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2701.88 | 10 | 20 | 22 | 19.6 | 20.1764 | 1.80632 | 0.545 | 0.65 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 264.075 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1620.35 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 315.133 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 261.073 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 420.005 | 10 | 15 | 18 | 16 | 24.3213 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1190.14 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1106 | 10 | 32 | 35 | 32 | 9.93031 | 1.7034 | 1.36996 | 1.4 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2770.02 | 10 | 25 | 28 | 25.6 | 12.1141 | 1.63196 | 0.84 | 0.84 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3555.12 | 10 | 20 | 22 | 19.6 | 21.1693 | 1.85603 | 0.56 | 0.56 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4782.45 | 10 | 15 | 18 | 16 | 18.5412 | 1.49208 | 0.3 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3634.88 | 30 | 12 | 15 | 13 | 7.09315 | 0.86444 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.114739 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5656.27 | 30 | 12 | 15 | 13 | 4.77838 | 0.690991 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0917168 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3473.85 | 30 | 12 | 15 | 13 | 2.74744 | 0.504119 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0669129 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3459.85 | 10 | 25 | 28 | 25.6 | 10.3848 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5592.27 | 10 | 25 | 28 | 25.6 | 13.9616 | 1.76796 | 0.91 | 1.3 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4223.88 | 10 | 32 | 35 | 32 | 8.98513 | 1.6102 | 1.295 | 1.85 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 188.589 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 249.532 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3933.88 | 40 | 25 | 28 | 25.6 | 7.54352 | 1.42796 | 0.735 | 1.05 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.114739 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5606.27 | 30 | 20 | 22 | 19.6 | 14.8966 | 1.74003 | 0.525 | 0.75 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0917168 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3455.85 | 30 | 15 | 18 | 16 | 22.6658 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0669129 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 188.157 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3620.89 | 10 | 20 | 22 | 19.6 | 21.1693 | 1.85603 | 0.56 | 0.8 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 268.454 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 260.656 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 263.579 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 300.372 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4219.36 | 10 | 15 | 18 | 16 | 24.3213 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 267.09 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1412.47 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 25 | 28 | 25.6 | 10.3848 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5586.12 | 10 | 25 | 28 | 25.6 | 10.3848 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 207.642 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2095.48 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 267.756 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2831.84 | 10 | 15 | 18 | 16 | 20.2024 | 1.56668 | 0.315 | 0.45 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 185.533 | 30 | 15 | 18 | 16 | 6.36054 | 0.940009 | 0.189 | 0.27 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 269.628 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3018.02 | 10 | 32 | 35 | 32 | 10.1251 | 1.72211 | 1.385 | 1.385 | DN 32 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3317.57 | 10 | 32 | 35 | 32 | 6.8128 | 1.37768 | 1.108 | 1.108 | DN 32 6m | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
30 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 141.623 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2534 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 188.493 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 645.749 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 91 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2718.36 | 10 | 20 | 22 | 19.6 | 23.5679 | 1.97204 | 0.595 | 0.73 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2165.95 | 10 | 20 | 22 | 19.6 | 23.5679 | 1.97204 | 0.595 | 0.73 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2349.3 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2784 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
25 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 111.981 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 101.225 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2584 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2237.66 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1883.95 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2271.35 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 184 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1209.87 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 555.287 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 112.295 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 59.7275 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 317.559 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1120.75 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 84 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3168.96 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1029.71 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 345.115 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2520.5 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 845.394 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2123.44 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3774.29 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 341 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 32 | 35 | 32 | 8.75083 | 1.80168 | 1.449 | 2.07 | DN 32 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 10.9781 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2551.63 | 40 | 32 | 35 | 32 | 8.75083 | 1.80168 | 1.449 | 2.07 | DN 32 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 10.9781 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 107.421 | 40 | 32 | 35 | 32 | 8.75083 | 1.80168 | 1.449 | 2.07 | DN 32 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 10.9781 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 500.047 | 40 | 32 | 35 | 32 | 8.75083 | 1.80168 | 1.449 | 2.07 | DN 32 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 10.9781 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4162.96 | 40 | 32 | 35 | 32 | 8.75083 | 1.80168 | 1.449 | 2.07 | DN 32 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 10.9781 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3355 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1301.35 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 191.05 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1170 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 93.0574 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 158.132 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4780.31 | 70 | 50 | 54 | 51 | 3.21012 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3355 | 10 | 50 | 54 | 51 | 4.01546 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1401.35 | 10 | 50 | 54 | 51 | 4.01546 | 1.41177 | 2.884 | 4.12 | DN 50 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 65 | 76.1 | 72.1 | 3.31221 | 1.60453 | 6.551 | 8.51 | DN 65 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0c94a1d0-3d32-45b6-8dca-5e46eec327d7 | 39009 | 261.121
Systemrohr CrNiMo | EG_Verwaltung_FFB | 687.05 | 10 | 65 | 76.1 | 72.1 | 3.31221 | 1.60453 | 6.551 | 8.51 | DN 65 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0c94a1d0-3d32-45b6-8dca-5e46eec327d7 | 39009 | 261.121
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1088 | 10 | 65 | 76.1 | 72.1 | 3.31221 | 1.60453 | 6.551 | 8.51 | DN 65 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0c94a1d0-3d32-45b6-8dca-5e46eec327d7 | 39009 | 261.121
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4557.3 | 10 | 65 | 76.1 | 72.1 | 3.31221 | 1.60453 | 6.551 | 8.51 | DN 65 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0c94a1d0-3d32-45b6-8dca-5e46eec327d7 | 39009 | 261.121
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 50 | 54 | 51 | 3.55828 | 1.31925 | 2.695 | 3.61 | DN 50 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2626.63 | 10 | 50 | 54 | 51 | 3.55828 | 1.31925 | 2.695 | 3.61 | DN 50 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118
Systemrohr CrNiMo | EG_Verwaltung_FFB | 480.047 | 10 | 50 | 54 | 51 | 3.55828 | 1.31925 | 2.695 | 3.61 | DN 50 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3992.96 | 10 | 50 | 54 | 51 | 3.55828 | 1.31925 | 2.695 | 3.61 | DN 50 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/994f7c25-0904-487c-b23a-61f4e3b812bf | 39008 | 261.118
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 20 | 22 | 19.6 | 23.5679 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4931.18 | 10 | 20 | 22 | 19.6 | 23.5679 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1058.46 | 10 | 20 | 22 | 19.6 | 23.5679 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 94 | 10 | 15 | 18 | 16 | 9.92436 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1706.4 | 10 | 15 | 18 | 16 | 9.92436 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1999.06 | 10 | 15 | 18 | 16 | 9.92436 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2773.28 | 10 | 15 | 18 | 16 | 9.92436 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3106 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 220.177 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4529.39 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4941.97 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 74 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 676.369 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 116.607 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 152.666 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0662018 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 65.6079 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0662018 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 107.381 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2894 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 919.122 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 74 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 507.369 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4641.97 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4885.63 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 537.155 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 55.1599 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0662018 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3094 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
7 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1152.78 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 86 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 138.984 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 53.6761 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0662018 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2910 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 927.123 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 82 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2574.53 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2487.06 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2314.4 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 102 | 30 | 12 | 15 | 13 | 1.982 | 0.418169 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1073.46 | 30 | 12 | 15 | 13 | 6.78207 | 0.842777 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.111864 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 6.78207 | 0.842777 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.111864 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4405.18 | 30 | 12 | 15 | 13 | 6.78207 | 0.842777 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.111864 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 20 | 22 | 19.6 | 3.43798 | 0.76546 |  |  | DN 20 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2417.63 | 30 | 20 | 22 | 19.6 | 3.43798 | 0.76546 |  |  | DN 20 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 99.4214 | 30 | 20 | 22 | 19.6 | 3.43798 | 0.76546 |  |  | DN 20 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492.047 | 30 | 20 | 22 | 19.6 | 3.43798 | 0.76546 |  |  | DN 20 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4316.96 | 30 | 20 | 22 | 19.6 | 3.43798 | 0.76546 |  |  | DN 20 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.230953 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4952.31 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 162.132 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 111.057 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1202 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1428.05 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 102 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 98.3292 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 62.5163 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 67.153 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 389.35 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3371 | 40 | 25 | 28 | 25.6 | 3.44486 | 0.921773 |  |  | DN 25 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 6.3431 | 0.811442 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5003.51 | 30 | 12 | 15 | 13 | 6.3431 | 0.811442 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 915.578 | 30 | 12 | 15 | 13 | 6.3431 | 0.811442 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 295 | 30 | 12 | 15 | 13 | 6.3431 | 0.811442 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 142.401 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2592 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 632.834 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
6 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5248.49 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
