Properties of the parts of a building model (IFC2X3), part 2 of 10

# IfcFlowFitting: T-Stück egal (99)
Name | Tech-DN1 = Tech-DN2 = Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
T-Stück egal | 20 | 10 | DN 20 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/77c00b35-45e9-4a67-9231-aa553f847744 | 31004 | 264.114

# IfcFlowFitting: T-Stück reduziert (94)
In: EG_Verwaltung_FFB
Description: T-Stück reduziert
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: T-Stück reduziert; Tech-Catalog: Geberit; Tech-Product type: T-Stück reduziert; Tech-Manufacturer: Geberit
Name | Tech-DN1 | Tech-DN2 | Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
18 x T-Stück reduziert | 25 | 25 | 15 | 40 | DN 25 - 15 - 25 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f3a06af-437f-48e1-9791-0b46737779fc | 31210 | 264.135
3 x T-Stück reduziert | 32 | 32 | 15 | 10 | DN 32 - 15 - 32 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/c99510b7-a02d-4fce-a6ae-1cfe2a8f590c | 31213 | 264.136
T-Stück reduziert | 32 | 32 | 25 | 10 | DN 32 - 25 - 32 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/4bc5225a-f6c3-4765-b9b6-0a1a957bda2d | 31215 | 264.136
T-Stück reduziert | 32 | 25 | 20 | 10 | DN 32 - 20 - 25 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/3e88c972-ec4f-423e-8f4b-160afa46c921 | 31235 | 264.136
2 x T-Stück reduziert | 20 | 20 | 15 | 10 | DN 20 - 15 - 20 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/8cae90ba-d773-4dcb-9ea3-c494c9c08282 | 31207 | 264.134
6 x T-Stück reduziert | 15 | 15 | 12 | 30 | DN 15 - 12 - 15 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/5fa47c0e-5751-407f-ade2-d71276f230de | 31204 | 264.133
2 x T-Stück reduziert | 20 | 15 | 15 | 10 | DN 20 - 15 - 15 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/cd047783-552b-406e-b4db-19fc74a150d8 | 31228 | 264.134
3 x T-Stück reduziert | 15 | 12 | 12 | 30 | DN 15 - 12 - 12 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/67ec2020-2c5e-4916-82a8-ec7ca91d1dbc | 31208 | 264.133
16 x T-Stück reduziert | 20 | 20 | 15 | 30 | DN 20 - 15 - 20 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/8cae90ba-d773-4dcb-9ea3-c494c9c08282 | 31207 | 264.134
5 x T-Stück reduziert | 20 | 15 | 15 | 30 | DN 20 - 15 - 15 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/cd047783-552b-406e-b4db-19fc74a150d8 | 31228 | 264.134
T-Stück reduziert | 100 | 100 | 32 | 10 | DN 100 - 32 - 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/80f3e3dd-038e-44ba-ab6f-59fcdf9da554 | 31246 | 264.143
T-Stück reduziert | 100 | 100 | 40 | 10 | DN 100 - 40 - 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/371b13ca-75f6-4325-8592-255c61a9ee8f | 31247 | 264.143
2 x T-Stück reduziert | 25 | 25 | 15 | 10 | DN 25 - 15 - 25 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f3a06af-437f-48e1-9791-0b46737779fc | 31210 | 264.135
T-Stück reduziert | 32 | 25 | 25 | 40 | DN 32 - 25 - 25 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d15a27a8-5804-4a62-8b8b-93026a7eb944 | 31242 | 264.136
T-Stück reduziert | 50 | 50 | 25 | 70 | DN 50 - 25 - 50 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/efad8185-09b9-4521-bfe7-90278076d6f0 | 31224 | 264.138
T-Stück reduziert | 50 | 50 | 20 | 70 | DN 50 - 20 - 50 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/ef5d2bc8-ac26-4de0-8509-d8d2986b6cb0 | 31223 | 264.138
T-Stück reduziert | 80 | 80 | 65 | 10 | DN 80 - 65 - 80 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/c18da428-a7e6-4441-9464-2fb21ff0e965 | 31241 | 264.142
T-Stück reduziert | 65 | 65 | 40 | 10 | DN 65 - 40 - 65 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/84a318ea-c72f-4626-ac6e-810d45d7d7b3 | 31232 | 264.141
T-Stück reduziert | 65 | 65 | 32 | 10 | DN 65 - 32 - 65 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a8a3b29c-006a-48d1-9de7-cc86c6b39480 | 31231 | 264.141
T-Stück reduziert | 50 | 50 | 25 | 10 | DN 50 - 25 - 50 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/efad8185-09b9-4521-bfe7-90278076d6f0 | 31224 | 264.138
2 x T-Stück reduziert | 40 | 40 | 32 | 10 | DN 40 - 32 - 40 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/cacc4913-c675-40b2-be44-06be3f959fd1 | 31220 | 264.137
6 x T-Stück reduziert | 20 | 15 | 15 | 10 | DN 20 - 15 - 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/cd047783-552b-406e-b4db-19fc74a150d8 | 31228 | 264.134
T-Stück reduziert | 20 | 15 | 12 | 30 | DN 20 - 12 - 15 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/e38b4c20-68bd-48ba-9226-0806a013bef2 | 31227 | 264.134
T-Stück reduziert | 25 | 25 | 15 | 40 | DN 25 - 15 - 25 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/6f3a06af-437f-48e1-9791-0b46737779fc | 31210 | 264.135
T-Stück reduziert | 25 | 25 | 12 | 40 | DN 25 - 12 - 25 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/7a548bf2-9cca-4f70-8944-93c71d5dec40 | 31209 | 264.135
T-Stück reduziert | 40 | 40 | 20 | 10 | DN 40 - 20 - 40 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/afd179f0-42e9-4e74-be81-d44435663531 | 31218 | 264.137
2 x T-Stück reduziert | 32 | 25 | 20 | 10 | DN 32 - 20 - 25 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/3e88c972-ec4f-423e-8f4b-160afa46c921 | 31235 | 264.136
3 x T-Stück reduziert | 25 | 25 | 15 | 10 | DN 25 - 15 - 25 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f3a06af-437f-48e1-9791-0b46737779fc | 31210 | 264.135
2 x T-Stück reduziert | 32 | 32 | 15 | 10 | DN 32 - 15 - 32 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/c99510b7-a02d-4fce-a6ae-1cfe2a8f590c | 31213 | 264.136
T-Stück reduziert | 25 | 25 | 20 | 10 | DN 25 - 20 - 25 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a5b909dd-f055-49ec-9144-50ba5a97a326 | 31211 | 264.135
T-Stück reduziert | 80 | 80 | 40 | 20 | DN 80 - 40 - 80 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/b0a0cbbf-0c34-42e0-8308-bcbdd6e25d5b | 31239 | 264.142
T-Stück reduziert | 40 | 40 | 15 | 10 | DN 40 - 15 - 40 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/4e8c770c-4b94-4ed4-b71b-c55083e6228d | 31217 | 264.137
2 x T-Stück reduziert | 32 | 32 | 15 | 10 | DN 32 - 15 - 32 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/c99510b7-a02d-4fce-a6ae-1cfe2a8f590c | 31213 | 264.136
T-Stück reduziert | 25 | 25 | 15 | 10 | DN 25 - 15 - 25 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f3a06af-437f-48e1-9791-0b46737779fc | 31210 | 264.135
T-Stück reduziert | 20 | 15 | 15 | 10 | DN 20 - 15 - 15 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/cd047783-552b-406e-b4db-19fc74a150d8 | 31228 | 264.134

# IfcFlowFitting: Übergangsstück (4)
In: EG_Verwaltung_FFB
Description: Übergangsstück
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 30 mm; Name: Übergangsstück; Tech-Product item: Lokales Bauteil
Name | Tech-DN1 | Tech-DN2 | Tech-Medium
3 x Übergangsstück | 15 | 12 | S_Zirkulation
Übergangsstück | 25 | 20 | S_Warmwasser

# IfcFlowSegment: HT-Rohr (236)
Description: HT-Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Rohr; Name: HT-Rohr
Name | In | Geom-Length (mm) (mm) | Tech-DN | Info | Floor | Floor No. | Building = Building No.
HT-Rohr | Wartung_FFB | 63.4686 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 10614.8 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 1426.09 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 2853.64 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 3614.34 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 242.571 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 13539.1 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 19991.2 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 212.889 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Rohr | Wartung_FFB | 2980.7 | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
5 x HT-Rohr | EG_Verwaltung_FFB | 99.0503 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 231.438 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 654.043 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 546.297 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 49.4518 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 154.137 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 101.812 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1821.14 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 24.2226 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
10 x HT-Rohr | EG_Verwaltung_FFB | 2174.05 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 269.143 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 222.894 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 27.5127 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 268.018 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 61.608 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 28.7855 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 2175.86 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 339.415 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 269.076 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 12.8396 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1.61855 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 249.725 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Rohr | EG_Verwaltung_FFB | 2621.98 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 2175 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 596.43 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 452.747 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 573.913 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Rohr | EG_Verwaltung_FFB | 681.04 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 96.6547 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 5.31565 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 674.216 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 942.892 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 17.745 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 213.941 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 399.05 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 402.61 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 15.878 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 421.246 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 269.985 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 27.2534 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 100.152 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 830.91 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
7 x HT-Rohr | EG_Verwaltung_FFB | 159.05 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 167.715 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 9.0055 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 16.0957 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 50.2188 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 316.625 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 53.6531 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 467.655 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1955.33 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 439.93 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 914.665 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 214.071 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 96.98 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 109.424 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 89.869 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 395.926 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1005.28 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 2.28558 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 85.1624 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 96.2973 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 336.497 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 207.1 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 338.394 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 205.646 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 584.135 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 71.6893 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 92.6448 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 11.2534 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 173.691 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 95.083 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 186.683 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 99.7438 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 37.1246 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1.94247 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 6.43534 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 62.449 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 634.038 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 546.133 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 643.038 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 27.1811 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 14.8471 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 39.3275 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 44.4642 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 429.885 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 719.839 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x HT-Rohr | EG_Verwaltung_FFB | 2.13964 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 89.2556 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 39.6137 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x HT-Rohr | EG_Verwaltung_FFB | 698.046 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Rohr | EG_Verwaltung_FFB | 637.146 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Rohr | EG_Verwaltung_FFB | 736.046 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x HT-Rohr | EG_Verwaltung_FFB | 177.143 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 237.093 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 957.715 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 12.6169 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 102.219 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 122.883 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 125.385 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 689.475 | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 117.413 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 25.5326 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 91.6543 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 114.945 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 682.519 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 681.204 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 72.3558 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 73.6303 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 27.5875 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 73.4664 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 107.051 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 32.6358 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 53.3151 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 228.29 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 704.707 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 139.952 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 147.911 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 39.6124 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 3020.34 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 70.7584 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 710.89 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1046.26 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Rohr | EG_Verwaltung_FFB | 374.05 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 208.596 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 217.353 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1008.55 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 2000 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 451.609 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 715.219 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1041.06 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 208.58 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 217.35 | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 5094.63 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 667.859 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 99.5821 | 50 | DN 50 (da=56mm) | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 2175.96 | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 3548.16 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 1764 | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Rohr | EG_Verwaltung_FFB | 37.2992 | 50 | DN 50 (da=56mm)
HT-Rohr | EG_Verwaltung_FFB | 87.7274 | 50 | DN 50 (da=56mm)
HT-Rohr | EG_Verwaltung_FFB | 159.05 | 40 | DN 40
HT-Rohr | EG_Verwaltung_FFB | 536.821 | 90 | DN 90
HT-Rohr | EG_Verwaltung_FFB | 1047.36 | 50 | DN 50 (da=56mm)
HT-Rohr | EG_Verwaltung_FFB | 186.712 | 90 | DN 90
HT-Rohr | EG_Verwaltung_FFB | 445.03 | 70 | DN 70
2 x HT-Rohr | EG_Verwaltung_FFB | 672.04 | 70 | DN 70
HT-Rohr | EG_Verwaltung_FFB | 584.135 | 50 | DN 50 (da=56mm)
HT-Rohr | EG_Verwaltung_FFB | 681.04 | 50 | DN 50 (da=56mm)
HT-Rohr | EG_Verwaltung_FFB | 99.0503 | 40 | DN 40
HT-Rohr | EG_Verwaltung_FFB | 107.05 | 40 | DN 40
HT-Rohr | EG_Verwaltung_FFB | 124.55 | 40 | DN 40
HT-Rohr | EG_Verwaltung_FFB | 132.55 | 40 | DN 40
HT-Rohr | EG_Verwaltung_FFB | 140.55 | 40 | DN 40
HT-Rohr | EG_Verwaltung_FFB | 3435.04 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 228.428 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 3386.18 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 662.801 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 5748.9 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 563.915 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 5781.39 | 50 | DN 50 (da=56mm)
HT-Rohr | EG_Verwaltung_FFB | 479.532 | 100 | DN 100
2 x HT-Rohr | EG_Verwaltung_FFB | 171.857 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 2320.49 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 173.246 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 2755.3 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 23639 | 100 | DN 100
2 x HT-Rohr | EG_Verwaltung_FFB | 1563.91 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 1553.69 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 242.571 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 263.736 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 132.801 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 5650.27 | 100 | DN 100
HT-Rohr | EG_Verwaltung_FFB | 376.614 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 561.552 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 550.352 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 539.152 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 527.952 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 516.752 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 550.388 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 538.259 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 527.059 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 515.859 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 504.659 | 50 | DN 50 (da=56mm)
HT-Rohr | Grundleitungsebene | 62.4223 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 20678.3 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 228.428 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 6139 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 122.425 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 1625.74 | 100 | DN 100
HT-Rohr | Grundleitungsebene | 418.196 | 100 | DN 100

# IfcFlowSegment: KG-Rohr (346)
In: Grundleitungsebene
Description: KG-Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Catalog: Abwasserrohre 05/2013; Tech-System: KG-Rohr (DIN EN 1401 / DIN V 19534); Tech-Product name: KG-Rohr; Name: KG-Rohr
Name | Geom-Length (mm) (mm) | Tech-DN | Tech-Medium | Info
KG-Rohr | 33318.5 | 250 | S_Schmutzwasser | DN/OD 250
KG-Rohr | 30971.8 | 200 | S_Schmutzwasser | DN/OD 200
KG-Rohr | 3652.15 | 200 | S_Schmutzwasser | DN/OD 200
KG-Rohr | 1454.11 | 200 | S_Schmutzwasser | DN/OD 200
KG-Rohr | 718.814 | 150 | S_Schmutzwasser | DN/OD 160
KG-Rohr | 5045.31 | 150 | S_Schmutzwasser | DN/OD 160
KG-Rohr | 6420.93 | 150 | S_Schmutzwasser | DN/OD 160
KG-Rohr | 526.198 | 150 | S_Schmutzwasser | DN/OD 160
KG-Rohr | 2416.36 | 150 | S_Schmutzwasser | DN/OD 160
KG-Rohr | 247.998 | 150 | S_Schmutzwasser | DN/OD 160
KG-Rohr | 8693.51 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 10.779 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 4966.59 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 2278.82 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 61.5952 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 532.993 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 79.7361 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 3131.71 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 362.35 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 39.1762 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 2523.58 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 381.317 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 296.232 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 413.88 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 74.4578 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 16815.7 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 949.4 | 100 | S_Schmutzwasser | DN/OD 110
7 x KG-Rohr | 902.056 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 1495.38 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 347.028 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 534.659 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 78.0147 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 179.324 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 55.6821 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 65.5697 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 171.297 | 125 | S_Schmutzwasser | DN/OD 125
KG-Rohr | 478.837 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 562.944 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 3.91817 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 1024.18 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 14.4629 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 34.375 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 582.108 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 98.8887 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 6162.78 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 16275.3 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 634.609 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 88.0081 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 467.593 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 170.695 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 276.321 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 384.5 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 831.448 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 543.874 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 43.3802 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 6596.43 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 554.393 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 85.9707 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 6085.53 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 4585.86 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 5836.24 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 6190.82 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 304.969 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 4961.75 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 364.71 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 211.436 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 479.485 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 171.671 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 849.388 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 530.769 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 293.053 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 763.558 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 578.45 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 88.7862 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 3756.53 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 4941.26 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 580.32 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 583.464 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 477.32 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 635.064 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 102.77 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 863.037 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 704.534 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 190.975 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 2172.8 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 710.066 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 16107 | 250 | S_Schmutzwasser | DN/OD 250
KG-Rohr | 325.264 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 6368.65 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 714.372 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 4609.62 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 4951.17 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
2 x KG-Rohr | 166.848 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1266.67 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 34.2292 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 7296.83 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 2257.98 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 7554.83 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
KG-Rohr | 5856.37 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 718.488 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 690.892 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 271.319 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 378.461 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 8447.33 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2410.23 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2486.7 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 293.921 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2105.8 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 12.3123 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1947.19 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1105.49 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 519.027 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 138.528 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1570.49 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 133.318 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3258.09 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2246.95 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1135.41 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
2 x KG-Rohr | 359.574 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 257.6 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 81.3844 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 672.438 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 107.087 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1561.51 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 125.303 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 5141.74 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 177.555 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 3988.04 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 5165.65 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 1045.24 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 20556.2 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 6855.52 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 3223.1 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 415.066 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 7310.81 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 878.661 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 269.525 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 3259.16 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 4519.52 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1759.97 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3693.17 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 16248.6 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3200.06 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 707.902 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 184.821 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 362.31 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 61.5913 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 131.267 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 284.973 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 149.44 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 5493.76 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 664.54 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3211.04 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 662.546 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 559.983 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 559.546 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 123.913 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1124 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 140.869 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2230.82 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 136.644 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 3898.5 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 997.649 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 164.185 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 1100.96 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 375.717 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 3617.07 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 720.023 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 236 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 5747.05 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 393.218 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 8208.73 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 53.5965 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 324.38 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 113.447 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 533.996 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 224.4 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 993.031 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1029.99 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 381.667 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 13.8727 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 26.2925 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 915.275 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 131.357 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1001.31 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1814.94 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 503.963 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1421.17 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
2 x KG-Rohr | 237.56 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 166.223 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 163.175 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 637.39 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 382.71 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 472.88 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 141.631 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1027.53 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 131.867 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 4325.97 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1713.31 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 157.582 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 439.515 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 6.96958 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1572.16 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 371.67 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 132.082 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 344.759 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 583.44 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 11.7441 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 133.006 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3956.46 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 96.6604 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 35.6338 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 174.747 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1053.55 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 143.794 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 11624.9 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2291.83 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 492.688 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 48.9537 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 39.3559 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 160.97 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1447.06 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1308.5 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 4271.28 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 904.497 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 118.896 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1421.85 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 49.4203 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1048.46 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 53.3956 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 290.538 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 56.8115 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 288.122 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 378.507 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 574.293 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 62.1792 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 913.869 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 402.691 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 205.947 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 266.371 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3727.16 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 697.911 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 796.42 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 180.599 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 654.572 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 165.6 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 149.534 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1022.1 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 248.763 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 352.656 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 138.082 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 6429.19 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 29658.2 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 224.586 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1076.8 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 470.082 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 88.755 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 527.243 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 163.254 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1085.37 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 72.0611 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 11302.4 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 453.67 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
KG-Rohr | 518.272 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 1803.35 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 1646.63 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 4998.58 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
KG-Rohr | 2517.59 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 6082.33 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3076.7 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1898.73 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 440.006 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 4020.28 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 387.611 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 240.041 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 661.639 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 183.09 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1262.71 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 169.509 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1793.43 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 199.83 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2231.85 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 876.295 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 245.759 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 85.3427 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2587.79 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 587.414 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2056.51 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 81.6202 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1058.27 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 141.49 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 497.333 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 64.2503 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 402.179 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 116.34 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 515.69 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 144.093 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 670.9 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 184.946 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 1331.58 | 100 | S_Schmutzwasser | DN/OD 110
KG-Rohr | 88.7743 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2156.39 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3683.76 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 240.603 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 72.9639 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 425.703 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 231.21 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 156.573 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 128.463 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 151.963 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 148.57 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 2930.81 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 7353.51 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 369.612 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
KG-Rohr | 760.117 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 570.271 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 385.297 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 179.34 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2722.9 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 329.32 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 931.903 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1521.53 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 41.9207 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 390.622 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 24.677 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 1194.27 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 131.128 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 779.806 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 81.4391 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 3166.79 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 88.6022 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 696.018 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 2216.56 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 160.335 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 634.189 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 76.4865 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
KG-Rohr | 633.418 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110

# IfcFlowSegment: PE-Rohr (112)
Description: PE-Rohr
Pset_MEP - Tech-Catalog: Abwasserrohre 05/2013; Tech-System: PE; Tech-Product name: PE-Rohr; Name: PE-Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Name | In | Pset_MEP, Geom-Length (mm) (mm) | Tech-DN | Tech-Medium | Info | Floor | Floor No. | Building = Building No.
PE-Rohr | Wartung_FFB | 5100 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
6 x PE-Rohr | Wartung_FFB | 4900 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 4467 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 5200 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x PE-Rohr | Wartung_FFB | 4300 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB |  | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II | Pset_MEP - Geom-Length (mm): 100 m
PE-Rohr | Wartung_FFB | 2200 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 3000 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 5700 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 4934.41 | 100 | S_Abwasser_Entlueftung | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 5173.07 | 100 | S_Abwasser_Entlueftung | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 5426 | 100 | S_Abwasser_Entlueftung | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 178.265 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 1589.15 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 600 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 648 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
6 x PE-Rohr | Wartung_FFB | 800 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 417 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 663 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 660 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 4427 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 295.135 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 1500 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 68.1589 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x PE-Rohr | Wartung_FFB | 996 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 700 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 700.035 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 1298.27 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 6600 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 643.503 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Wartung_FFB | 4430 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Wartung_FFB | 1341.13 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Wartung_FFB | 4750 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Wartung_FFB | 4600 | 150 | S_Abwasser_Entlueftung | DN 150
PE-Rohr | Wartung_FFB | 838 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Wartung_FFB | 292.469 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Wartung_FFB |  | 100 | S_Schmutzwasser | DN 100 | Pset_MEP - Geom-Length (mm): 2400 m
PE-Rohr | Wartung_FFB | 3549 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
2 x PE-Rohr | Wartung_FFB | 1300 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 3261 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Wartung_FFB | 1654 | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 7035 | 100 | S_Abwasser_Entlueftung | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 5010 | 70 | S_Schmutzwasser | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x PE-Rohr | EG_Verwaltung_FFB | 5000 | 70 | S_Schmutzwasser | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 2000 | 70 | S_Schmutzwasser | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 100.772 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 6778 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 6315 | 70 | S_Schmutzwasser | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 6344 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 81.4749 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 54.8477 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 6525 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 72.2749 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 6802 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 7015 | 100 | S_Schmutzwasser | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 4800 | 150 | S_Abwasser_Entlueftung | DN 150 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
PE-Rohr | EG_Verwaltung_FFB | 345.354 | 150 | S_Abwasser_Entlueftung | DN 150
PE-Rohr | EG_Verwaltung_FFB | 1256.79 | 150 | S_Abwasser_Entlueftung | DN 150
PE-Rohr | EG_Verwaltung_FFB | 167.116 | 150 | S_Abwasser_Entlueftung | DN 150
PE-Rohr | EG_Verwaltung_FFB | 466.506 | 150 | S_Abwasser_Entlueftung | DN 150
PE-Rohr | EG_Verwaltung_FFB | 90.9564 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | EG_Verwaltung_FFB | 3936.18 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | EG_Verwaltung_FFB | 900 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | EG_Verwaltung_FFB | 1209.44 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | EG_Verwaltung_FFB | 2377.65 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | EG_Verwaltung_FFB | 334.02 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Grundleitungsebene | 1100 | 150 | S_Abwasser_Entlueftung | DN 150 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Grundleitungsebene | 4012.11 | 150 | S_Abwasser_Entlueftung | DN 150 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II
PE-Rohr | Grundleitungsebene | 1888.87 | 100 | S_Schmutzwasser | DN 100
PE-Rohr | Grundleitungsebene | 385.812 | 100 | S_Schmutzwasser | DN 100
2 x PE-Rohr | Grundleitungsebene | 1258.65 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 3172.02 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 2454.64 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 1891.18 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 6719.57 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 688.082 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 4003.4 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 2089.24 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 3592.97 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 1263.62 | 125 | S_SW_Druckleitung | DN 125
PE-Rohr | Grundleitungsebene | 163.977 | 125 | S_SW_Druckleitung | DN 125
2 x PE-Rohr | Grundleitungsebene | 1297.65 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 2780.53 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 865.24 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 1958.67 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 6624.96 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 681.782 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 2214.63 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 1808.48 | 70 | S_Schmutzwasser_Grundleitung | DN 70
