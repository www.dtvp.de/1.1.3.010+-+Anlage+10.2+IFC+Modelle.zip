Properties of the parts of a building model (IFC2X3), part 5 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 979.97 | 10 | 25 | 28 | 25.6 | 8.26695 | 1.31489 | 0.676796 | 1.62 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 241 | 10 | 25 | 28 | 25.6 | 8.91214 | 1.37203 | 0.706208 | 1.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 977.526 | 10 | 25 | 28 | 25.6 | 8.91214 | 1.37203 | 0.706208 | 1.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 241 | 10 | 25 | 28 | 25.6 | 9.54023 | 1.42592 | 0.733948 | 1.92 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 980.258 | 10 | 25 | 28 | 25.6 | 9.54023 | 1.42592 | 0.733948 | 1.92 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 241 | 10 | 25 | 28 | 25.6 | 10.1528 | 1.47698 | 0.760229 | 2.07 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 582.559 | 10 | 25 | 28 | 25.6 | 10.1528 | 1.47698 | 0.760229 | 2.07 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 347.817 | 10 | 25 | 28 | 25.6 | 10.1528 | 1.47698 | 0.760229 | 2.07 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 10.1528 | 1.47698 | 0.760229 | 2.07 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 10.4336 | 1.49994 | 0.772046 | 2.14 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 629.852 | 10 | 25 | 28 | 25.6 | 10.4336 | 1.49994 | 0.772046 | 2.14 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 10.711 | 1.52238 | 0.783598 | 2.21 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 499.939 | 10 | 25 | 28 | 25.6 | 10.711 | 1.52238 | 0.783598 | 2.21 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.227 | 10 | 25 | 28 | 25.6 | 10.711 | 1.52238 | 0.783598 | 2.21 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 10.986 | 1.54434 | 0.794901 | 2.28 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.227 | 10 | 25 | 28 | 25.6 | 10.986 | 1.54434 | 0.794901 | 2.28 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 11.2583 | 1.56584 | 0.805967 | 2.35 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 452.671 | 10 | 25 | 28 | 25.6 | 11.2583 | 1.56584 | 0.805967 | 2.35 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.698 | 10 | 25 | 28 | 25.6 | 11.2583 | 1.56584 | 0.805967 | 2.35 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 11.5279 | 1.5869 | 0.816807 | 2.42 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.698 | 10 | 25 | 28 | 25.6 | 11.5279 | 1.5869 | 0.816807 | 2.42 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 11.7949 | 1.60755 | 0.827433 | 2.49 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 457.586 | 10 | 25 | 28 | 25.6 | 11.7949 | 1.60755 | 0.827433 | 2.49 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.698 | 10 | 25 | 28 | 25.6 | 11.7949 | 1.60755 | 0.827433 | 2.49 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 12.0594 | 1.62779 | 0.837856 | 2.56 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.698 | 10 | 25 | 28 | 25.6 | 12.0594 | 1.62779 | 0.837856 | 2.56 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 12.3215 | 1.64766 | 0.848083 | 2.63 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 653.33 | 10 | 25 | 28 | 25.6 | 12.3215 | 1.64766 | 0.848083 | 2.63 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 12.5813 | 1.66717 | 0.858124 | 2.7 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 658.666 | 10 | 25 | 28 | 25.6 | 12.5813 | 1.66717 | 0.858124 | 2.7 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 99.0693 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2442 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 415.228 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3777.84 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3491.23 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 142.468 | 10 | 25 | 28 | 25.6 | 12.8388 | 1.68633 | 0.867987 | 2.77 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 13.0941 | 1.70516 | 0.87768 | 2.84 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 657.125 | 10 | 25 | 28 | 25.6 | 13.0941 | 1.70516 | 0.87768 | 2.84 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 13.3473 | 1.72368 | 0.887209 | 2.91 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 665.376 | 10 | 25 | 28 | 25.6 | 13.3473 | 1.72368 | 0.887209 | 2.91 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 13.5984 | 1.74189 | 0.896581 | 2.98 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 656.408 | 10 | 25 | 28 | 25.6 | 13.5984 | 1.74189 | 0.896581 | 2.98 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 13.8476 | 1.7598 | 0.905803 | 3.05 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 652.675 | 10 | 25 | 28 | 25.6 | 13.8476 | 1.7598 | 0.905803 | 3.05 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 251 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 338.5 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2442 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 135.228 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 959.719 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1516.63 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 614.059 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 402 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 583.534 | 10 | 25 | 28 | 25.6 | 14.0947 | 1.77744 | 0.914879 | 3.12 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 727 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 735 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 752.5 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 768.5 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 218.5 | 40 | 25 | 28 | 25.6 | 6.43469 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2242 | 40 | 25 | 28 | 25.6 | 6.43469 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3400.37 | 40 | 25 | 28 | 25.6 | 6.43469 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3789.93 | 40 | 25 | 28 | 25.6 | 6.43469 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 474.923 | 40 | 25 | 28 | 25.6 | 6.43469 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 486.427 | 40 | 25 | 28 | 25.6 | 6.43469 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
10 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 467 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 84.4401 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 938.316 | 30 | 20 | 22 | 19.6 | 13.6834 | 1.65969 | 0.500758 | 0.9 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 57.9558 | 30 | 20 | 22 | 19.6 | 13.6834 | 1.65969 | 0.500758 | 0.9 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 119.684 | 30 | 20 | 22 | 19.6 | 13.6834 | 1.65969 | 0.500758 | 0.9 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 137.396 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 203.56 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.56 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 81.4401 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 760.5 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 65.5 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2242 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 214.923 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 959.719 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1395.35 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 435.339 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 402 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 295.534 | 40 | 25 | 28 | 25.6 | 7.62328 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 60 | 10 | 20 | 22 | 19.6 | 22.2096 | 1.90703 | 0.575386 | 1.17 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 101.531 | 10 | 20 | 22 | 19.6 | 22.2096 | 1.90703 | 0.575386 | 1.17 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 68.4686 | 10 | 20 | 22 | 19.6 | 22.2096 | 1.90703 | 0.575386 | 1.17 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 250 | 10 | 20 | 22 | 19.6 | 22.2096 | 1.90703 | 0.575386 | 1.17 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 60 | 10 | 20 | 22 | 19.6 | 19.9238 | 1.7935 | 0.541132 | 1.04 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 798.577 | 10 | 20 | 22 | 19.6 | 19.9238 | 1.7935 | 0.541132 | 1.04 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 60 | 10 | 20 | 22 | 19.6 | 17.5579 | 1.6697 | 0.50378 | 0.91 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 797.556 | 10 | 20 | 22 | 19.6 | 17.5579 | 1.6697 | 0.50378 | 0.91 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 60 | 10 | 20 | 22 | 19.6 | 15.1008 | 1.53302 | 0.46254 | 0.78 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 798.203 | 10 | 20 | 22 | 19.6 | 15.1008 | 1.53302 | 0.46254 | 0.78 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 60 | 10 | 20 | 22 | 19.6 | 12.5395 | 1.37957 | 0.416241 | 0.65 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 791.035 | 10 | 20 | 22 | 19.6 | 12.5395 | 1.37957 | 0.416241 | 0.65 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 25.9396 | 1.80553 | 0.363023 | 0.52 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 805.622 | 10 | 15 | 18 | 16 | 25.9396 | 1.80553 | 0.363023 | 0.52 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 806.79 | 10 | 15 | 18 | 16 | 18.5009 | 1.49023 | 0.299628 | 0.39 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 810.356 | 10 | 15 | 18 | 16 | 10.7096 | 1.09098 | 0.219354 | 0.26 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 812.74 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 452 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4125.24 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 242 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 511.281 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 796.577 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2358.35 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4789.61 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2082 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 81.7462 | 30 | 12 | 15 | 13 | 1.57859 | 0.366949 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 58.1585 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2307 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 550.705 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2619.27 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2904.6 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 349.059 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 450 | 30 | 12 | 15 | 13 | 0.735036 | 0.236021 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 357 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 139.396 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 541 | 10 | 25 | 28 | 25.6 | 6.87127 | 1.18405 | 0.609454 | 1.31 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 976.663 | 10 | 25 | 28 | 25.6 | 6.87127 | 1.18405 | 0.609454 | 1.31 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 541 | 10 | 25 | 28 | 25.6 | 7.55788 | 1.24975 | 0.643271 | 1.46 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1024.76 | 10 | 25 | 28 | 25.6 | 7.55788 | 1.24975 | 0.643271 | 1.46 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 135.469 | 10 | 25 | 28 | 25.6 | 7.55788 | 1.24975 | 0.643271 | 1.46 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 648.764 | 10 | 25 | 28 | 25.6 | 7.87091 | 1.27883 | 0.658235 | 1.53 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.069 | 10 | 25 | 28 | 25.6 | 8.17955 | 1.30699 | 0.672734 | 1.6 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.069 | 10 | 25 | 28 | 25.6 | 8.48402 | 1.33432 | 0.686801 | 1.67 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 553.102 | 10 | 25 | 28 | 25.6 | 8.48402 | 1.33432 | 0.686801 | 1.67 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.069 | 10 | 25 | 28 | 25.6 | 8.78452 | 1.36087 | 0.700467 | 1.74 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.069 | 10 | 25 | 28 | 25.6 | 9.08123 | 1.3867 | 0.713759 | 1.81 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 539.987 | 10 | 25 | 28 | 25.6 | 9.08123 | 1.3867 | 0.713759 | 1.81 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 652.061 | 10 | 25 | 28 | 25.6 | 9.37432 | 1.41184 | 0.726701 | 1.88 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 342.595 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2542 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3491.86 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2135.5 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 441.991 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 247.901 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 59.9181 | 10 | 25 | 28 | 25.6 | 9.66393 | 1.43635 | 0.739314 | 1.95 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 59.9181 | 10 | 25 | 28 | 25.6 | 9.95022 | 1.46025 | 0.751619 | 2.02 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 652.936 | 10 | 25 | 28 | 25.6 | 9.95022 | 1.46025 | 0.751619 | 2.02 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 59.9181 | 10 | 25 | 28 | 25.6 | 10.2333 | 1.48359 | 0.763633 | 2.09 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 645.138 | 10 | 25 | 28 | 25.6 | 10.2333 | 1.48359 | 0.763633 | 2.09 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 59.9181 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 141.407 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2542 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 161.991 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 732.665 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1516.63 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 614.059 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 421 | 10 | 25 | 28 | 25.6 | 10.5133 | 1.5064 | 0.775373 | 2.16 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
10 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 167 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 222.595 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 251.499 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 733.517 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1395.35 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 435.339 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 424 | 40 | 25 | 28 | 25.6 | 5.35301 | 1.17949 | 0.607106 | 1.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 84.5953 | 30 | 20 | 22 | 19.6 | 16.443 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2360 | 30 | 20 | 22 | 19.6 | 16.443 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3418.37 | 30 | 20 | 22 | 19.6 | 16.443 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2167.29 | 30 | 20 | 22 | 19.6 | 16.443 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 529.499 | 30 | 20 | 22 | 19.6 | 16.443 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 303.69 | 30 | 20 | 22 | 19.6 | 16.443 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
5 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 84.4401 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 203.56 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 77.5286 | 30 | 15 | 18 | 16 | 23.9215 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 71.9558 | 30 | 15 | 18 | 16 | 23.9215 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 984.471 | 30 | 15 | 18 | 16 | 23.9215 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 550 | 10 | 20 | 22 | 19.6 | 22.0364 | 1.89862 | 0.572847 | 1.16 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 68.4686 | 10 | 20 | 22 | 19.6 | 22.0364 | 1.89862 | 0.572847 | 1.16 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 997.411 | 10 | 20 | 22 | 19.6 | 22.0364 | 1.89862 | 0.572847 | 1.16 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 550 | 10 | 20 | 22 | 19.6 | 19.3853 | 1.76592 | 0.532811 | 1.01 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 68.4686 | 10 | 20 | 22 | 19.6 | 19.3853 | 1.76592 | 0.532811 | 1.01 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 991.512 | 10 | 20 | 22 | 19.6 | 19.3853 | 1.76592 | 0.532811 | 1.01 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 550 | 10 | 20 | 22 | 19.6 | 16.6243 | 1.61883 | 0.488432 | 0.86 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 68.4686 | 10 | 20 | 22 | 19.6 | 16.6243 | 1.61883 | 0.488432 | 0.86 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 101.531 | 10 | 20 | 22 | 19.6 | 16.6243 | 1.61883 | 0.488432 | 0.86 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 160 | 10 | 20 | 22 | 19.6 | 16.6243 | 1.61883 | 0.488432 | 0.86 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 160 | 10 | 20 | 22 | 19.6 | 14.1288 | 1.47625 | 0.445413 | 0.73 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 792.945 | 10 | 20 | 22 | 19.6 | 14.1288 | 1.47625 | 0.445413 | 0.73 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 757 | 10 | 15 | 18 | 16 | 30.3407 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 859.844 | 10 | 15 | 18 | 16 | 30.3407 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 167 | 10 | 15 | 18 | 16 | 30.3407 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 757 | 10 | 15 | 18 | 16 | 21.9797 | 1.64355 | 0.330456 | 0.45 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 654.694 | 10 | 15 | 18 | 16 | 21.9797 | 1.64355 | 0.330456 | 0.45 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 757 | 10 | 15 | 18 | 16 | 13.1391 | 1.22619 | 0.24654 | 0.3 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 652.147 | 10 | 15 | 18 | 16 | 13.1391 | 1.22619 | 0.24654 | 0.3 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 757 | 10 | 15 | 18 | 16 | 5.52426 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 696 | 10 | 15 | 18 | 16 | 5.52426 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 467 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0418074 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 477 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 138 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 458.102 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1475.9 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3345.62 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 722.567 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2384 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 60.3945 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 107 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 107 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 64.6623 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2384 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1968.15 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5640.99 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 783.258 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 319.164 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2484 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 166.184 | 10 | 15 | 18 | 16 | 7.65506 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 107 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 54.7906 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2484 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 164.103 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4018.67 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 577.077 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 962.742 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 166.184 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 107 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 54.7906 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2484 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 745.442 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3697.57 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 992.545 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 601.291 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2384 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 84 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 80.9959 | 10 | 32 | 35 | 32 | 12.9459 | 1.977 | 1.59 | 12.09 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
