Properties of the parts of a building model (IFC2X3), part 7 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1461.83 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1595.27 | 30 | 12 | 15 | 13 | 2.3667 | 0.462898 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 250.572 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0757933 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 55.8231 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0757933 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1126.59 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 702.157 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3142 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 91.7028 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 447.455 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 115 | 10 | 40 | 42 | 39 | 6.64517 | 1.55786 | 1.861 | 2.05 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 417.509 | 10 | 40 | 42 | 39 | 6.64517 | 1.55786 | 1.861 | 2.05 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 100 | 10 | 40 | 42 | 39 | 6.64517 | 1.55786 | 1.861 | 2.05 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 40 | 42 | 39 | 6.64517 | 1.55786 | 1.861 | 2.05 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2869.65 | 10 | 40 | 42 | 39 | 6.64517 | 1.55786 | 1.861 | 2.05 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 290.276 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 454.449 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 626.786 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 87.7501 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 108.036 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0757933 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2584 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 511.977 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4037.91 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 452.27 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 140.649 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 63.7753 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 64.9431 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2584 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 452.27 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 395.778 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1539.78 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1767.32 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 20 | 22 | 19.6 | 13.16 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4844.51 | 30 | 20 | 22 | 19.6 | 13.16 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1135.58 | 30 | 20 | 22 | 19.6 | 13.16 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 271 | 30 | 20 | 22 | 19.6 | 13.16 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2284 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 143.896 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 366.221 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 893.65 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 510.018 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 809.292 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 244 | 30 | 15 | 18 | 16 | 19.1011 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2284 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 470.498 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 581.506 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 622.758 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 88.4155 | 30 | 15 | 18 | 16 | 12.8088 | 1.39261 | 0.28 | 0.4 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2484 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 658.411 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 107 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 62.0737 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3534 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1315.4 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 861.68 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 606.957 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 214.551 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 127 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1381.99 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 787.889 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5876.38 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 995.087 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2184 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 194.505 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 415.07 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2484 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 888.836 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 109.811 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2284 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 558.246 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1132.47 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 995.087 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2184 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 431.07 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 115.947 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 171.803 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2105.39 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 731.906 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 98.2192 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2184 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3466.99 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2899.68 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 547.013 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 772.925 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 82.964 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3134 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 60.5308 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 54.7684 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5648.33 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1007.3 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2384 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 255.487 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 280.539 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 586.762 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 227 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 40 | 42 | 39 | 7.09678 | 1.61645 | 1.931 | 2.15 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1271.82 | 10 | 40 | 42 | 39 | 7.09678 | 1.61645 | 1.931 | 2.15 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1846.27 | 10 | 40 | 42 | 39 | 7.09678 | 1.61645 | 1.931 | 2.15 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 40 | 42 | 39 | 10.0817 | 1.96804 | 2.351 | 2.75 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4680.51 | 10 | 40 | 42 | 39 | 10.0817 | 1.96804 | 2.351 | 2.75 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1355.58 | 10 | 40 | 42 | 39 | 10.0817 | 1.96804 | 2.351 | 2.75 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 247 | 10 | 40 | 42 | 39 | 10.0817 | 1.96804 | 2.351 | 2.75 | DN 40 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/bd555b5c-d7cc-4611-ab5a-750ef6f923bf | 39007 | 261.117
Systemrohr CrNiMo | EG_Verwaltung_FFB | 179.958 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 241.923 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 607.451 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2400 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 810.177 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5086.08 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 432.539 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 912.77 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 252 | 30 | 12 | 15 | 13 | 1.44349 | 0.348544 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
5 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2942 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 452.508 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 144 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2549.82 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2075.17 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 575.988 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 319.117 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 606.154 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 141 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 147.677 | 10 | 20 | 22 | 19.6 | 15.8847 | 1.57763 | 0.476 | 0.56 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 241.014 | 10 | 20 | 22 | 19.6 | 15.8847 | 1.57763 | 0.476 | 0.56 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1791.93 | 10 | 20 | 22 | 19.6 | 15.8847 | 1.57763 | 0.476 | 0.56 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 131 | 10 | 20 | 22 | 19.6 | 15.8847 | 1.57763 | 0.476 | 0.56 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 126.593 | 10 | 15 | 18 | 16 | 16.4247 | 1.39261 | 0.28 | 0.28 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 3142 | 10 | 15 | 18 | 16 | 5.52426 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 627.29 | 10 | 15 | 18 | 16 | 5.52426 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3402.96 | 10 | 15 | 18 | 16 | 5.52426 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 639.29 | 10 | 15 | 18 | 16 | 5.52426 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 153.563 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 391 | 30 | 15 | 18 | 16 | 3.54335 | 0.675393 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.135796 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.54335 | 0.675393 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.135796 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 551.757 | 30 | 15 | 18 | 16 | 3.54335 | 0.675393 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.135796 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 409.204 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1267.51 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3380 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 196.411 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1656 | 30 | 12 | 15 | 13 | 0.880637 | 0.262072 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 58.5015 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 225.558 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2534 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 113.69 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 623.29 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2807.42 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 225.572 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 512.411 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1601 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 355 | 10 | 32 | 35 | 32 | 11.7388 | 1.87131 | 1.505 | 2.15 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 32 | 35 | 32 | 11.7388 | 1.87131 | 1.505 | 2.15 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5769.76 | 10 | 32 | 35 | 32 | 11.7388 | 1.87131 | 1.505 | 2.15 | DN 32 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3867.53 | 10 | 15 | 18 | 16 | 9.92436 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1009.63 | 10 | 15 | 18 | 16 | 9.92436 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 209 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 368.192 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2109 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 146 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0309313 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 367.76 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3625.45 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1682.79 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2232.74 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2134 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 242.961 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 123.093 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 101.527 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2534 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3426.79 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1682.79 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 693.152 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 116.009 | 10 | 15 | 18 | 16 | 4.901 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 98.749 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 192.755 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 55.1671 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 150.532 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 475.899 | 30 | 12 | 15 | 13 | 0.371591 | 0.15864 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 30 | 12 | 15 | 13 | 0.371591 | 0.15864 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3835.99 | 30 | 12 | 15 | 13 | 0.371591 | 0.15864 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1690.79 | 30 | 12 | 15 | 13 | 0.371591 | 0.15864 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4307.69 | 30 | 12 | 15 | 13 | 0.371591 | 0.15864 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 693.627 | 30 | 12 | 15 | 13 | 0.371591 | 0.15864 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 104.093 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2134 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2232.74 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4067.81 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 793.351 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 361 | 40 | 25 | 28 | 25.6 | 11.8604 | 1.83595 | 0.945 | 1.35 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.135796 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 11.8604 | 1.83595 | 0.945 | 1.35 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.135796 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 144.757 | 40 | 25 | 28 | 25.6 | 11.8604 | 1.83595 | 0.945 | 1.35 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.135796 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 94.7345 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2134 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 322.337 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1342.64 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 395.846 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 296.136 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1650 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
