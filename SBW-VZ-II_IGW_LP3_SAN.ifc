Properties of the parts of a building model (IFC2X3), part 8 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200.721 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 997.352 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2688.42 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 984.745 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 192.337 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2146 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0466969 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 60.5464 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0466969 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 397.795 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 977.362 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 119.386 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 72.4664 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0466969 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 341.613 | 30 | 15 | 18 | 16 | 10.0923 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2234 | 30 | 15 | 18 | 16 | 10.0923 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 167.402 | 30 | 15 | 18 | 16 | 10.0923 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2546.78 | 30 | 15 | 18 | 16 | 10.0923 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 735.438 | 30 | 15 | 18 | 16 | 10.0923 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 793.351 | 30 | 15 | 18 | 16 | 10.0923 | 1.21853 | 0.245 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0411514 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2434 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 241.088 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2546.78 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 285 | 10 | 20 | 22 | 19.6 | 16.7186 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 106.771 | 10 | 20 | 22 | 19.6 | 16.7186 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2420 | 10 | 20 | 22 | 19.6 | 16.7186 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 460.173 | 10 | 20 | 22 | 19.6 | 16.7186 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2056.73 | 10 | 20 | 22 | 19.6 | 16.7186 | 1.62403 | 0.49 | 0.7 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1384.26 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 112.72 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 10 | 15 | 18 | 16 | 20.8738 | 1.59606 | 0.320907 | 0.4 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 184 | 10 | 15 | 18 | 16 | 20.8738 | 1.59606 | 0.320907 | 0.4 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 9.11401 | 0.994718 | 0.2 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 111.82 | 10 | 15 | 18 | 16 | 9.11401 | 0.994718 | 0.2 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 833.983 | 10 | 15 | 18 | 16 | 9.11401 | 0.994718 | 0.2 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 112.72 | 10 | 15 | 18 | 16 | 9.11401 | 0.994718 | 0.2 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0340671 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 55.7274 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0340671 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 83.9964 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 197.31 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1387 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2339.36 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2884.99 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 406.359 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2234 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 277.495 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3072.17 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1322.95 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 442.255 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 72.5082 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 130.169 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 130.329 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 120.143 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0340671 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 55.3102 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1026.5 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1930.22 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 693.627 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 52 | 30 | 12 | 15 | 13 | 0.767703 | 0.242047 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 447.459 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2234 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 214.445 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2066.04 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3678.89 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3077.14 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 367.402 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 94.748 | 30 | 15 | 18 | 16 | 5.5492 | 0.870379 | 0.175 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 780.164 | 10 | 25 | 28 | 25.6 | 7.28498 | 1.22397 | 0.63 | 0.9 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 993.627 | 10 | 25 | 28 | 25.6 | 7.28498 | 1.22397 | 0.63 | 0.9 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2134 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 381.851 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 461.794 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 217.354 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0362358 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 61.1032 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0362358 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 260.5 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 160.268 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 261.52 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 139.627 | 10 | 15 | 18 | 16 | 8.58728 | 0.961346 | 0.19329 | 0.2 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 159.817 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 437 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 117.356 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 348.997 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 206.407 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 134 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 415.55 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2134 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 68.1032 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0362358 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 113.742 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 30 | 12 | 15 | 13 | 0.49191 | 0.186872 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 546.468 | 30 | 12 | 15 | 13 | 0.49191 | 0.186872 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 0.49191 | 0.186872 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1148.78 | 30 | 12 | 15 | 13 | 0.49191 | 0.186872 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 493.627 | 30 | 12 | 15 | 13 | 0.49191 | 0.186872 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 52 | 30 | 12 | 15 | 13 | 0.49191 | 0.186872 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3852.62 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1342.66 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1108.71 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 102.368 | 30 | 15 | 18 | 16 | 7.66986 | 1.04445 | 0.21 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 360.656 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2334 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2792.83 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 188.656 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2346 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.2 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0202295 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 71.7041 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 280.943 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.35 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 168.223 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
6 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1399.02 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 63.3236 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 199.857 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2342 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1481.51 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1214.89 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4005.76 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 52 | 30 | 12 | 15 | 13 | 0.432904 | 0.173449 | 0.28 | 0.28 | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 236.244 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 20.2024 | 1.56668 | 0.315 | 0.45 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 491.656 | 10 | 15 | 18 | 16 | 20.2024 | 1.56668 | 0.315 | 0.45 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2534 | 10 | 15 | 18 | 16 | 20.2024 | 1.56668 | 0.315 | 0.45 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2798.72 | 10 | 15 | 18 | 16 | 20.2024 | 1.56668 | 0.315 | 0.45 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 290.898 | 10 | 15 | 18 | 16 | 20.2024 | 1.56668 | 0.315 | 0.45 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3651.76 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1266.52 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 933.676 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2534 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 366.368 | 10 | 15 | 18 | 16 | 28.7747 | 1.91483 | 0.385 | 0.55 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 119.969 | 10 | 15 | 18 | 16 | 2.74061 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 124.688 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2642 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 318.516 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5327.03 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2825.68 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2692.59 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 198 | 30 | 12 | 15 | 13 | 1.96351 | 0.415927 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 270.099 | 30 | 15 | 18 | 16 | 10.4626 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 1734 | 30 | 15 | 18 | 16 | 10.4626 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4317.37 | 30 | 15 | 18 | 16 | 10.4626 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 117.099 | 30 | 15 | 18 | 16 | 10.4626 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 10.4626 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 24.3213 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1343.99 | 10 | 15 | 18 | 16 | 24.3213 | 1.74076 | 0.35 | 0.5 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 285 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 53.8984 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 85 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 234 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4054.11 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 450.968 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2520 | 10 | 20 | 22 | 19.6 | 12.7395 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 443.125 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2846 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 744.126 | 40 | 25 | 28 | 25.6 | 8.20148 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2602 | 40 | 25 | 28 | 25.6 | 8.20148 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 8.20148 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4471.53 | 40 | 25 | 28 | 25.6 | 8.20148 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2466.03 | 40 | 25 | 28 | 25.6 | 8.20148 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 171 | 40 | 25 | 28 | 25.6 | 8.20148 | 1.49596 | 0.77 | 1.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 606.439 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2620 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4440.64 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 220 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 875.066 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 247.403 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2320 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 80.1899 | 30 | 20 | 22 | 19.6 | 18.661 | 1.97204 | 0.595 | 0.85 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 596.438 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2834 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4759.11 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 247.043 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2320 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 366.29 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3604.11 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 220 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3130.68 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1008.42 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 117.912 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2620 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 219.981 | 30 | 20 | 22 | 19.6 | 9.98192 | 1.39203 | 0.42 | 0.6 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.055207 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 2.06793 | 0.497359 | 0.1 | 0.1 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 607.127 | 10 | 25 | 28 | 25.6 | 14.9289 | 1.83595 | 0.945 | 1.35 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2188.59 | 10 | 25 | 28 | 25.6 | 14.9289 | 1.83595 | 0.945 | 1.35 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 161 | 10 | 25 | 28 | 25.6 | 14.9289 | 1.83595 | 0.945 | 1.35 | DN 25 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 92.7491 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 210.705 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3096.18 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 248.099 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 1934 | 10 | 15 | 18 | 16 | 13.4639 | 1.2434 | 0.25 | 0.25 | DN 15 6m | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
