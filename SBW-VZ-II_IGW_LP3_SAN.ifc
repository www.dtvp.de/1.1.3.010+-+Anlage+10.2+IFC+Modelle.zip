Properties of the parts of a building model (IFC2X3), part 1 of 10

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2026-07-17T10:11:22+02:00
Author: Bra
Organization: IGW
Written by: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)
Made in: Trimble Nova (Build = 19.1.2.10, Compile = Mar 11 2026)

# IfcSite: Projektstandort, Default
RefLatitude: 49, 0, 3571; RefLongitude: 12, 15, -2; RefElevation: 0 m

# IfcSite: Pyramidenstumpf (6)
Description: Pyramidenstumpf
Pset_Basis - Name: Pyramidenstumpf; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Floor | Floor No.
2 x Pyramidenstumpf | Wartung_FFB | 2
2 x Pyramidenstumpf | EG_Verwaltung_FFB | 0
2 x Pyramidenstumpf | Grundleitungsebene | -1

# IfcBuilding: Gebäude, Speiseverteilzentrum SBW VZ II
Description: Speiseverteilzentrum SBW VZ II

# IfcBuildingStorey: Geschoss (4)
In: Speiseverteilzentrum SBW VZ II
Name | Description | Elevation (m)
Wartung_FFB | 2 | 7.1307
UK Thermische Hülle | 1 | 6.2307
EG_Verwaltung_FFB | 0 | 0.115653
Grundleitungsebene | -1 | -1.884

# IfcBuildingElementProxy: Abwasserleitung (22)
In: EG_Verwaltung_FFB
Description: Abwasserleitung

# IfcBuildingElementProxy: Distributor Abwasserleitung
In: EG_Verwaltung_FFB
Description: Distributor Abwasserleitung

# IfcBuildingElementProxy: IfcProxy (361)
Description: IfcProxy
Name | In
38 x IfcProxy | Wartung_FFB
294 x IfcProxy | EG_Verwaltung_FFB
29 x IfcProxy | Grundleitungsebene

# IfcBuildingElementProxy: Revisionswolke (58)
Description: Revisionswolke
Name | In
19 x Revisionswolke | Wartung_FFB
29 x Revisionswolke | EG_Verwaltung_FFB
10 x Revisionswolke | Grundleitungsebene

# IfcDistributionElement: Druckerhöhung (2)
In: EG_Verwaltung_FFB
Description: Druckerhöhung
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Druckerhöhung; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Info
Druckerhöhung | 60 kg
Druckerhöhung | 600 kg

# IfcDistributionElement: Enthärtung I (4)
In: EG_Verwaltung_FFB
Description: Enthärtung I
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Enthärtung I; Info: 1000 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Enthärtung II
In: EG_Verwaltung_FFB
Description: Enthärtung II
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Enthärtung II; Info: 1000 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Enthärtung III
In: EG_Verwaltung_FFB
Description: Enthärtung III
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Enthärtung III; Info: 1000 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Umkehrosmose (2)
In: EG_Verwaltung_FFB
Description: Umkehrosmose
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Umkehrosmose; Info: 500 kg; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcDistributionElement: Zylinder (11)
In: EG_Verwaltung_FFB
Description: Zylinder
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Zylinder; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcEnergyConversionDevice: Trinkwassererwärmer unmittelbar beheizt (2)
In: EG_Verwaltung_FFB
Description: Trinkwassererwärmer unmittelbar beheizt
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Width (mm): 800 mm; Geom-Height (mm): 1900 mm; Geom-Installation height (mm): 580 mm; Calc-Temperature OUT (°C): 75 C; Name: Trinkwassererwärmer unmittelbar beheizt; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Geom-Length (mm) (mm) | Calc-Total Pressure loss (Pa) (Pa) | Calc-Volumetric flow (m3/h) (m3/hour) | Pos. No.
Trinkwassererwärmer unmittelbar beheizt | 2200 | 496.016 | 1.70803 | 98
Trinkwassererwärmer unmittelbar beheizt | 1900 | 518.017 | 0.7087 | 6

# IfcFlowController: 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss (42)
In: EG_Verwaltung_FFB
Description: 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss; Tech-Product item: Lokales Bauteil
Name | Tech-DN | dp component (mbar) (hPa) | Tech-Medium
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 20 | 6.8076 | S_Kaltwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 1.70053 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.108435 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.108435 | S_Kaltwasser
2 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.857624 | S_Zirkulation
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 20 | 4.18258 | S_Kaltwasser
5 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.433741 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 3.2712 | S_Kaltwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 1.27456 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 18.5226 | S_Kaltwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 12.0957 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 13.3044 | S_Kaltwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 8.15649 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 1.20431 | S_Kaltwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 1.73496 | S_Warmwasser
2 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.975917 | S_enthaertetes_Wasser
2 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 4.98152 | S_Zirkulation
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 2.71088 | S_Warmwasser
2 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 20 | 3.90367 | S_enthaertetes_Wasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 40 | 15.7453 | S_enthaertetes_Wasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.433741 | S_enthaertetes_Wasser
2 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.975917 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 1.32833 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 8.78325 | S_enthaertetes_Wasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.826787 | S_enthaertetes_Wasser
2 x 135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 3.28017 | S_enthaertetes_Wasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 13.1207 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 19.7623 | S_enthaertetes_Wasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 25 | 11.955 | S_enthaertetes_Wasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.221296 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 15 | 0.790493 | S_Warmwasser
135 01, Freistrom-Absperrventil, ohne Entleerung, Flanschanschluss | 40 | 11.664 | S_Umkehrosmosewasser

# IfcFlowController: 143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS (18)
In: EG_Verwaltung_FFB
Description: 143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Tech-DN: 12; Settings: 65; Name: 143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS; Tech-Medium: S_Zirkulation; Tech-Product item: Lokales Bauteil
Name | dp component (mbar) (hPa) | dp throttle (mbar) (hPa)
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 0.891904 | 247.236
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 5.10289 | 370.169
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 0.891904 | 333.121
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 17.3447
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 12.0096 | 9.7301
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 4.96843 | 184.425
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 15.5963 | 20.7294
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 19.1112 | 58.5285
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 10.8351 | 172.873
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 6.12577 | 183.644
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 2.24463 | 303.47
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 5.22538 | 194.843
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 3.11462 | 222.613
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 2.68326 | 263.162
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 15.4295 | 228.927
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 12.9667 | 114.752
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 0.891904 | 189.226
143 22, MULTI-THERM automatisches Zirkulations-Regulierventil, 50 °C bis 65 °C, MAPRESS | 16.0804

# IfcFlowController: Pumpe (2)
In: EG_Verwaltung_FFB
Description: Pumpe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Insulation thickness (mm): 0 mm; Name: Pumpe; Tech-Medium: S_Zirkulation; Tech-Product item: Lokales Bauteil
Name | Tech-DN | dp (mbar) (Pa) | Nominal pressure (mbar) (hPa)
Pumpe | 15 | 51801.7 | 518.017
Pumpe | 25 | 49601.6 | 496.016

# IfcFlowController: Steuerschrank Hebeanlage (2)
In: EG_Verwaltung_FFB
Description: Steuerschrank Hebeanlage
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Steuerschrank Hebeanlage; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Name | Info
Steuerschrank Hebeanlage | (fäk.-frei) + Rückstauschleife
Steuerschrank Hebeanlage | (fäk.) + Rückstauschleife

# IfcFlowFitting: Bogen 45° (32)
In: EG_Verwaltung_FFB
Description: Bogen 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Bogen 45°; Tech-Catalog: Geberit; Tech-Product type: Bogen 45°; Tech-Manufacturer: Geberit
Name | Tech-DN | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
4 x Bogen 45° | 100 | 10 | DN 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/26d808be-6fec-40f3-8ce5-87f3a88c0779 | 32611 | 262.143
4 x Bogen 45° | 32 | 40 | DN 32 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/ab411b39-3191-41cd-b9ec-e84cab846968 | 32606 | 262.136
2 x Bogen 45° | 50 | 70 | DN 50 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/93c5242d-81e9-4214-bf85-a2705c75031b | 32608 | 262.138
2 x Bogen 45° | 65 | 10 | DN 65 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/e8a857de-afe4-43b2-93c0-5c1b5792b5e1 | 32609 | 262.141
4 x Bogen 45° | 50 | 10 | DN 50 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/93c5242d-81e9-4214-bf85-a2705c75031b | 32608 | 262.138
4 x Bogen 45° | 20 | 30 | DN 20 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/53153b41-de46-4f1a-a7df-87150528929d | 30604 | 262.134
2 x Bogen 45° | 25 | 40 | DN 25 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/40e1e84e-836e-4479-acc4-bec2faadc2bb | 30605 | 262.135
2 x Bogen 45° | 12 | 30 | DN 12 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4193176b-c95d-415d-a187-ba4910b07688 | 30602 | 262.132
2 x Bogen 45° | 20 | 30 | DN 20 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/53153b41-de46-4f1a-a7df-87150528929d | 30604 | 262.134
2 x Bogen 45° | 40 | 10 | DN 40 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/99390fff-a925-4fda-bda9-9658b184a3a8 | 32607 | 262.137
4 x Bogen 45° | 40 | 10 | DN 40 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/99390fff-a925-4fda-bda9-9658b184a3a8 | 32607 | 262.137

# IfcFlowFitting: Bogen 90° (1570)
Description: Bogen 90°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Bogen 90°; Tech-Catalog: Geberit; Tech-Product type: Bogen 90°; Tech-Manufacturer: Geberit
Name | In | Tech-DN | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
26 x Bogen 90° | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
35 x Bogen 90° | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | 262.113 | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
358 x Bogen 90° | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | 262.113
42 x Bogen 90° | EG_Verwaltung_FFB | 20 | 10 | DN 20 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7640ce35-4700-471b-8ce8-72114567da13 | 30104 | 262.114
178 x Bogen 90° | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | 262.113
178 x Bogen 90° | EG_Verwaltung_FFB | 25 | 10 | DN 25 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/5b73b192-ec43-4b14-9a6f-1cb7e21602cd | 30105 | 262.115
31 x Bogen 90° | EG_Verwaltung_FFB | 25 | 40 | DN 25 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/5b73b192-ec43-4b14-9a6f-1cb7e21602cd | 30105 | 262.115
8 x Bogen 90° | EG_Verwaltung_FFB | 32 | 10 | DN 32 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/934a4097-f0ba-4093-a9bb-86eddb3ca809 | 31106 | 262.116
85 x Bogen 90° | EG_Verwaltung_FFB | 20 | 10 | DN 20 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7640ce35-4700-471b-8ce8-72114567da13 | 30104 | 262.114
370 x Bogen 90° | EG_Verwaltung_FFB | 15 | 30 | DN 15 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | 262.113
119 x Bogen 90° | EG_Verwaltung_FFB | 12 | 30 | DN 12 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/f5216c57-c95c-41f9-9790-4787ddbb31fe | 30102 | 262.112
11 x Bogen 90° | EG_Verwaltung_FFB | 15 | 30 | DN 15 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | 262.113
25 x Bogen 90° | EG_Verwaltung_FFB | 20 | 30 | DN 20 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7640ce35-4700-471b-8ce8-72114567da13 | 30104 | 262.114
27 x Bogen 90° | EG_Verwaltung_FFB | 100 | 10 | DN 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/f20fab91-e2e3-405d-914d-e012fc9fe987 | 31111 | 262.123
Bogen 90° | EG_Verwaltung_FFB | 80 | 0 | DN 80 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d6ea87ca-2d6e-4804-8982-12da2ab8d46f | 31110 | 262.122
5 x Bogen 90° | EG_Verwaltung_FFB | 50 | 70 | DN 50 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/38490799-d05a-492e-bdd0-6f2b46d3e384 | 31108 | 262.118
Bogen 90° | EG_Verwaltung_FFB | 50 | 10 | DN 50 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/38490799-d05a-492e-bdd0-6f2b46d3e384 | 31108 | 262.118
3 x Bogen 90° | EG_Verwaltung_FFB | 65 | 10 | DN 65 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0b86533a-cc72-4451-a942-8af96f169803 | 31109 | 262.121
5 x Bogen 90° | EG_Verwaltung_FFB | 25 | 40 | DN 25 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/5b73b192-ec43-4b14-9a6f-1cb7e21602cd | 30105 | 262.115
4 x Bogen 90° | EG_Verwaltung_FFB | 40 | 10 | DN 40 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/527c0c0f-4c2c-49f1-82b5-aa5cd8b5392f | 31107 | 262.117
9 x Bogen 90° | EG_Verwaltung_FFB | 32 | 10 | DN 32 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/934a4097-f0ba-4093-a9bb-86eddb3ca809 | 31106 | 262.116
2 x Bogen 90° | EG_Verwaltung_FFB | 25 | 10 | DN 25 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/5b73b192-ec43-4b14-9a6f-1cb7e21602cd | 30105 | 262.115
6 x Bogen 90° | EG_Verwaltung_FFB | 80 | 10 | DN 80 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d6ea87ca-2d6e-4804-8982-12da2ab8d46f | 31110 | 262.122
Bogen 90° | EG_Verwaltung_FFB | 80 | 10 | DN 80 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d6ea87ca-2d6e-4804-8982-12da2ab8d46f | 31110 | 262.122
Bogen 90° | EG_Verwaltung_FFB | 80 | 20 | DN 80 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d6ea87ca-2d6e-4804-8982-12da2ab8d46f | 31110 | 262.122
4 x Bogen 90° | EG_Verwaltung_FFB | 40 | 10 | DN 40 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/527c0c0f-4c2c-49f1-82b5-aa5cd8b5392f | 31107 | 262.117
12 x Bogen 90° | EG_Verwaltung_FFB | 40 | 10 | DN 40 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/527c0c0f-4c2c-49f1-82b5-aa5cd8b5392f | 31107 | 262.117
18 x Bogen 90° | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/0d9d9730-430a-4474-83c7-72f582ad2f70 | 30103 | 262.113
Bogen 90° | EG_Verwaltung_FFB | 25 | 10 | DN 25 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/5b73b192-ec43-4b14-9a6f-1cb7e21602cd | 30105 | 262.115
Bogen 90° | EG_Verwaltung_FFB | 20 | 10 | DN 20 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7640ce35-4700-471b-8ce8-72114567da13 | 30104 | 262.114
3 x Bogen 90° | Grundleitungsebene | 100 | 20 | DN 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/f20fab91-e2e3-405d-914d-e012fc9fe987 | 31111 | 262.123

# IfcFlowFitting: HT-Abzweig scharf 45° (43)
Description: HT-Abzweig scharf 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 45 rad; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Abzweig scharf 45°; Name: HT-Abzweig scharf 45°
Name | In | Tech-DN | Tech-DN branch | Info | Floor | Floor No. | Building = Building No.
2 x HT-Abzweig scharf 45° | Wartung_FFB | 100 | 100 | 100/100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
10 x HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 50 | 50 | 50/50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
10 x HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 70 | 50 | 70/50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
8 x HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 90 | 90 | 90/90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 90 | 70 | 90/70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 100 | 100 | 100/100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 90 | 50 | 90/50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 90 | 50 | 90/50
3 x HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 70 | 50 | 70/50
HT-Abzweig scharf 45° | EG_Verwaltung_FFB | 50 | 50 | 50/50
HT-Abzweig scharf 45° | Grundleitungsebene | 100 | 100 | 100/100

# IfcFlowFitting: HT-Abzweig scharf 87,5° (17)
Description: HT-Abzweig scharf 87,5°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 87.5 rad; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Abzweig scharf 87,5°; Name: HT-Abzweig scharf 87,5°
Name | In | Tech-DN | Tech-DN branch | Info | Floor | Floor No. | Building = Building No.
2 x HT-Abzweig scharf 87,5° | Wartung_FFB | 100 | 100 | 100/100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
HT-Abzweig scharf 87,5° | EG_Verwaltung_FFB | 90 | 90 | 90/90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Abzweig scharf 87,5° | EG_Verwaltung_FFB | 50 | 50 | 50/50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x HT-Abzweig scharf 87,5° | EG_Verwaltung_FFB | 100 | 100 | 100/100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
6 x HT-Abzweig scharf 87,5° | EG_Verwaltung_FFB | 70 | 50 | 70/50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Abzweig scharf 87,5° | EG_Verwaltung_FFB | 100 | 50 | 100/50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Abzweig scharf 87,5° | EG_Verwaltung_FFB | 50 | 50 | 50/50

# IfcFlowFitting: HT-Bogen normal 15° (2)
In: EG_Verwaltung_FFB
Description: HT-Bogen normal 15°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 15 rad; Tech-DN: 50; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Bogen normal 15°; Tech-Order number: 2108; Name: HT-Bogen normal 15°; Info: DN 50; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: HT-Bogen normal 45° (103)
Description: HT-Bogen normal 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 45 rad; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Bogen normal 45°; Name: HT-Bogen normal 45°
Name | In | Tech-DN | Info | Floor | Floor No. | Building = Building No.
5 x HT-Bogen normal 45° | Wartung_FFB | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
39 x HT-Bogen normal 45° | EG_Verwaltung_FFB | 50 | DN 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x HT-Bogen normal 45° | EG_Verwaltung_FFB | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
3 x HT-Bogen normal 45° | EG_Verwaltung_FFB | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x HT-Bogen normal 45° | EG_Verwaltung_FFB | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x HT-Bogen normal 45° | EG_Verwaltung_FFB | 50 | DN 50
HT-Bogen normal 45° | EG_Verwaltung_FFB | 90 | DN 90
25 x HT-Bogen normal 45° | EG_Verwaltung_FFB | 100 | DN 100
10 x HT-Bogen normal 45° | Grundleitungsebene | 50 | DN 50
7 x HT-Bogen normal 45° | Grundleitungsebene | 100 | DN 100

# IfcFlowFitting: HT-Bogen normal 67° (4)
In: EG_Verwaltung_FFB
Description: HT-Bogen normal 67°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 67 rad; Tech-DN: 50; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Bogen normal 67°; Tech-Order number: 2110; Name: HT-Bogen normal 67°; Info: DN 50; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: HT-Bogen normal 87° (111)
Description: HT-Bogen normal 87°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 87 rad; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Bogen normal 87°; Name: HT-Bogen normal 87°
Name | In | Tech-DN | Info | Floor | Floor No. | Building = Building No.
4 x HT-Bogen normal 87° | Wartung_FFB | 100 | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
48 x HT-Bogen normal 87° | EG_Verwaltung_FFB | 40 | DN 40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
24 x HT-Bogen normal 87° | EG_Verwaltung_FFB | 50 | DN 50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
19 x HT-Bogen normal 87° | EG_Verwaltung_FFB | 90 | DN 90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
HT-Bogen normal 87° | EG_Verwaltung_FFB | 70 | DN 70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x HT-Bogen normal 87° | EG_Verwaltung_FFB | 100 | DN 100 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
7 x HT-Bogen normal 87° | EG_Verwaltung_FFB | 40 | DN 40
2 x HT-Bogen normal 87° | EG_Verwaltung_FFB | 50 | DN 50
HT-Bogen normal 87° | EG_Verwaltung_FFB | 90 | DN 90

# IfcFlowFitting: HT-Übergang exzentrisch (75)
In: EG_Verwaltung_FFB
Description: HT-Übergang exzentrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: HT-Rohr (DIN EN 1451 / DIN V 19560-10); Tech-Product name: HT-Übergang exzentrisch; Name: HT-Übergang exzentrisch
Name | Tech-DN 1 | Tech-DN 2 | Info | Floor | Floor No. | Building = Building No.
47 x HT-Übergang exzentrisch | 50 | 40 | 50x40 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
5 x HT-Übergang exzentrisch | 70 | 50 | 70x50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
8 x HT-Übergang exzentrisch | 100 | 90 | 100x90 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
4 x HT-Übergang exzentrisch | 90 | 70 | 90x70 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
2 x HT-Übergang exzentrisch | 90 | 50 | 90x50 | EG_Verwaltung_FFB | 0 | Speiseverteilzentrum SBW VZ II
7 x HT-Übergang exzentrisch | 50 | 40 | 50x40
HT-Übergang exzentrisch | 90 | 50 | 90x50
HT-Übergang exzentrisch | 70 | 50 | 70x50

# IfcFlowFitting: KG Übergangsrohr exzentrisch (18)
In: Grundleitungsebene
Description: KG Übergangsrohr exzentrisch
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-Catalog: Abwasserrohre 05/2013; Tech-System: KG-Rohr (DIN EN 1401 / DIN V 19534); Tech-Product name: KG Übergangsrohr exzentrisch; Name: KG Übergangsrohr exzentrisch
Name | Tech-DN 1 | Tech-DN 2 | Tech-Medium | Info
3 x KG Übergangsrohr exzentrisch | 125 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 125/110
KG Übergangsrohr exzentrisch | 250 | 200 | S_Schmutzwasser | DN/OD 250/200
KG Übergangsrohr exzentrisch | 200 | 150 | S_Schmutzwasser | DN/OD 200/160
KG Übergangsrohr exzentrisch | 150 | 125 | S_Schmutzwasser | DN/OD 160/125
2 x KG Übergangsrohr exzentrisch | 125 | 100 | S_Schmutzwasser | DN/OD 125/110
2 x KG Übergangsrohr exzentrisch | 250 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 250/200
4 x KG Übergangsrohr exzentrisch | 200 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 200/160
4 x KG Übergangsrohr exzentrisch | 150 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 160/110

# IfcFlowFitting: KG-Abzweig scharf 45° (109)
In: Grundleitungsebene
Description: KG-Abzweig scharf 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 45 rad; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: KG-Rohr (DIN EN 1401 / DIN V 19534); Tech-Product name: KG-Abzweig scharf 45°; Name: KG-Abzweig scharf 45°
Name | Tech-DN | Tech-DN branch | Tech-Medium | Info
17 x KG-Abzweig scharf 45° | 100 | 100 | S_Schmutzwasser | DN/OD 110/110
4 x KG-Abzweig scharf 45° | 125 | 100 | S_Schmutzwasser | DN/OD 125/110
8 x KG-Abzweig scharf 45° | 125 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 125/110
KG-Abzweig scharf 45° | 250 | 250 | S_Schmutzwasser | DN/OD 250/250
3 x KG-Abzweig scharf 45° | 200 | 100 | S_Schmutzwasser | DN/OD 200/110
5 x KG-Abzweig scharf 45° | 150 | 100 | S_Schmutzwasser | DN/OD 160/110
KG-Abzweig scharf 45° | 150 | 125 | S_Schmutzwasser | DN/OD 160/125
KG-Abzweig scharf 45° | 250 | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250/250
2 x KG-Abzweig scharf 45° | 250 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 250/110
KG-Abzweig scharf 45° | 250 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 250/200
5 x KG-Abzweig scharf 45° | 200 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 200/110
KG-Abzweig scharf 45° | 200 | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 200/160
11 x KG-Abzweig scharf 45° | 150 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 160/110
45 x KG-Abzweig scharf 45° | 100 | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110/110
KG-Abzweig scharf 45° | 200 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 200/125
KG-Abzweig scharf 45° | 200 | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200/200
KG-Abzweig scharf 45° | 150 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 160/125
KG-Abzweig scharf 45° | 125 | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125/125

# IfcFlowFitting: KG-Bogen 45° (322)
In: Grundleitungsebene
Description: KG-Bogen 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 45 rad; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: KG-Rohr (DIN EN 1401 / DIN V 19534); Tech-Product name: KG-Bogen 45°; Name: KG-Bogen 45°
Name | Tech-DN | Tech-Medium | Info
5 x KG-Bogen 45° | 125 | S_Schmutzwasser | DN/OD 125
215 x KG-Bogen 45° | 100 | S_Schmutzwasser | DN/OD 110
7 x KG-Bogen 45° | 250 | S_Schmutzwasser_Fetthaltig | DN/OD 250
85 x KG-Bogen 45° | 100 | S_Schmutzwasser_Fetthaltig | DN/OD 110
3 x KG-Bogen 45° | 150 | S_Schmutzwasser_Fetthaltig | DN/OD 160
2 x KG-Bogen 45° | 200 | S_Schmutzwasser_Fetthaltig | DN/OD 200
3 x KG-Bogen 45° | 125 | S_Schmutzwasser_Fetthaltig | DN/OD 125
2 x KG-Bogen 45° | 150 | S_Schmutzwasser | DN/OD 160

# IfcFlowFitting: Muffe (170)
Description: Muffe
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Muffe; Tech-Catalog: Geberit; Tech-Product type: Muffe; Tech-Manufacturer: Geberit
Name | In | Tech-DN1 = Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
15 x Muffe | EG_Verwaltung_FFB | 25 | 40 | DN 25 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/1372d608-c6a0-433c-bb3b-63693f4dfe89 | 32005 | 265.115
6 x Muffe | EG_Verwaltung_FFB | 32 | 10 | DN 32 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6ff80687-3a7c-45b2-8319-227eac26228d | 32006 | 265.116
8 x Muffe | EG_Verwaltung_FFB | 15 | 30 | DN 15 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/35a41543-3dd8-4df9-8c27-047e6a45cffc | 32003 | 265.113
32 x Muffe | EG_Verwaltung_FFB | 12 | 30 | DN 12 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/19eeb59e-ccd2-4402-9506-0a78b42908dd | 32002 | 265.112
5 x Muffe | EG_Verwaltung_FFB | 20 | 10 | DN 20 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/2d56e238-c655-462f-934b-3d4224f201de | 32004 | 265.114
29 x Muffe | EG_Verwaltung_FFB | 15 | 30 | DN 15 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/35a41543-3dd8-4df9-8c27-047e6a45cffc | 32003 | 265.113
3 x Muffe | EG_Verwaltung_FFB | 25 | 10 | DN 25 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/1372d608-c6a0-433c-bb3b-63693f4dfe89 | 32005 | 265.115
Muffe | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/35a41543-3dd8-4df9-8c27-047e6a45cffc | 32003 | 265.113
13 x Muffe | EG_Verwaltung_FFB | 100 | 10 | DN 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/87bd854b-327f-439e-86c6-4471bb9fb25c | 32011 | 265.123
7 x Muffe | EG_Verwaltung_FFB | 40 | 10 | DN 40 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/07aab381-b213-4a48-b115-3332cb3ddf56 | 32007 | 265.117
3 x Muffe | EG_Verwaltung_FFB | 20 | 10 | DN 20 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/2d56e238-c655-462f-934b-3d4224f201de | 32004 | 265.114
Muffe | EG_Verwaltung_FFB | 25 | 10 | DN 25 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/1372d608-c6a0-433c-bb3b-63693f4dfe89 | 32005 | 265.115
Muffe | EG_Verwaltung_FFB | 32 | 40 | DN 32 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6ff80687-3a7c-45b2-8319-227eac26228d | 32006 | 265.116
2 x Muffe | EG_Verwaltung_FFB | 50 | 70 | DN 50 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/4d5504a5-8d78-4705-ab53-9680c0f513c3 | 32008 | 265.118
2 x Muffe | EG_Verwaltung_FFB | 65 | 10 | DN 65 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/9cfb0212-5d7b-4a2a-975e-aa4d0e8141e1 | 32009 | 265.121
Muffe | EG_Verwaltung_FFB | 50 | 10 | DN 50 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/4d5504a5-8d78-4705-ab53-9680c0f513c3 | 32008 | 265.118
14 x Muffe | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/35a41543-3dd8-4df9-8c27-047e6a45cffc | 32003 | 265.113
Muffe | EG_Verwaltung_FFB | 20 | 30 | DN 20 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/2d56e238-c655-462f-934b-3d4224f201de | 32004 | 265.114
2 x Muffe | EG_Verwaltung_FFB | 25 | 40 | DN 25 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/1372d608-c6a0-433c-bb3b-63693f4dfe89 | 32005 | 265.115
5 x Muffe | EG_Verwaltung_FFB | 20 | 30 | DN 20 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/2d56e238-c655-462f-934b-3d4224f201de | 32004 | 265.114
2 x Muffe | EG_Verwaltung_FFB | 32 | 10 | DN 32 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6ff80687-3a7c-45b2-8319-227eac26228d | 32006 | 265.116
Muffe | EG_Verwaltung_FFB | 40 | 10 | DN 40 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/07aab381-b213-4a48-b115-3332cb3ddf56 | 32007 | 265.117
11 x Muffe | EG_Verwaltung_FFB | 40 | 10 | DN 40 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/07aab381-b213-4a48-b115-3332cb3ddf56 | 32007 | 265.117
2 x Muffe | EG_Verwaltung_FFB | 15 | 10 | DN 15 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/35a41543-3dd8-4df9-8c27-047e6a45cffc | 32003 | 265.113
2 x Muffe | Grundleitungsebene | 100 | 20 | DN 100 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/05f23912-58a5-4829-80b3-b83851cb577a | 32011 | 265.123
Muffe | Grundleitungsebene | 100 | 0 | DN 100 | B_E-Kabel | 5992b63d-acee-48f0-9c27-8831f02f2006/87bd854b-327f-439e-86c6-4471bb9fb25c | 32011 | 265.123

# IfcFlowFitting: PE-Abzweig scharf 88.5° (8)
In: EG_Verwaltung_FFB
Description: PE-Abzweig scharf 88.5°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 88.5 rad; Tech-DN: 100; Tech-Medium: S_Schmutzwasser; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: PE; Tech-Product name: PE-Abzweig scharf 88.5°; Name: PE-Abzweig scharf 88.5°
Name | Tech-DN branch | Info
3 x PE-Abzweig scharf 88.5° | 100 | 100/100 | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
PE-Abzweig scharf 88.5° | 70 | 100/70
3 x PE-Abzweig scharf 88.5° | 100 | 100/100
PE-Abzweig scharf 88.5° | 50 | 100/50

# IfcFlowFitting: PE-Bogen langer Schenkel gr. Radius 90° (19)
In: Grundleitungsebene
Description: PE-Bogen langer Schenkel gr. Radius 90°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 90 rad; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: PE; Tech-Product name: PE-Bogen langer Schenkel gr. Radius 90°; Name: PE-Bogen langer Schenkel gr. Radius 90°
Name | Tech-DN | Tech-Medium | Info
9 x PE-Bogen langer Schenkel gr. Radius 90° | 125 | S_SW_Druckleitung | DN 125
10 x PE-Bogen langer Schenkel gr. Radius 90° | 70 | S_Schmutzwasser_Grundleitung | DN 70

# IfcFlowFitting: PE-Bogen normal 45° (7)
In: Grundleitungsebene
Description: PE-Bogen normal 45°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 45 rad; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: PE; Tech-Product name: PE-Bogen normal 45°; Name: PE-Bogen normal 45°
Name | Tech-DN | Tech-Medium | Info
PE-Bogen normal 45° | 150 | S_Abwasser_Entlueftung | DN 150 | Pset_MEP - Floor: Grundleitungsebene; Floor No.: -1; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
2 x PE-Bogen normal 45° | 100 | S_Schmutzwasser | DN 100
PE-Bogen normal 45° | 125 | S_SW_Druckleitung | DN 125
3 x PE-Bogen normal 45° | 70 | S_Schmutzwasser_Grundleitung | DN 70

# IfcFlowFitting: PE-Bogen normal 88.5° (38)
Description: PE-Bogen normal 88.5°
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Geom-Angle (°): 88.5 rad; Tech-Catalog: Abwasserrohre 05/2013; Tech-System: PE; Tech-Product name: PE-Bogen normal 88.5°; Name: PE-Bogen normal 88.5°
Name | In | Tech-DN | Tech-Medium | Info | Floor | Floor No. | Building = Building No.
33 x PE-Bogen normal 88.5° | Wartung_FFB | 100 | S_Schmutzwasser | DN 100 | Wartung_FFB | 2 | Speiseverteilzentrum SBW VZ II
4 x PE-Bogen normal 88.5° | EG_Verwaltung_FFB | 150 | S_Abwasser_Entlueftung | DN 150
PE-Bogen normal 88.5° | Grundleitungsebene | 150 | S_Abwasser_Entlueftung | DN 150 | Grundleitungsebene | -1 | Speiseverteilzentrum SBW VZ II

# IfcFlowFitting: Reduktion mit Einschubende (33)
In: EG_Verwaltung_FFB
Description: Reduktion mit Einschubende
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Reduktion mit Einschubende; Tech-Catalog: Geberit; Tech-Product type: Reduktion mit Einschubende; Tech-Manufacturer: Geberit
Name | Tech-DN1 | Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
3 x Reduktion mit Einschubende | 25 | 20 | 30 | DN 25 - 20 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a0f47c2f-a359-42a1-bec5-568e625ae128 | 32309 | 265.315
Reduktion mit Einschubende | 32 | 25 | 10 | DN 32 - 25 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d9d4f277-164d-4038-9b59-23e6229ae887 | 32313 | 265.316
8 x Reduktion mit Einschubende | 15 | 12 | 30 | DN 15 - 12 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/1df2aeca-89a4-4366-9cb1-df9bb17685dd | 32303 | 265.313
Reduktion mit Einschubende | 32 | 20 | 10 | DN 32 - 20 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/b1e9ab5d-2634-4665-bb06-d41e4d4e8ad0 | 32312 | 265.316
2 x Reduktion mit Einschubende | 25 | 15 | 30 | DN 25 - 15 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/1ec78e3b-b252-475d-b454-bf154aa799b8 | 32308 | 265.315
Reduktion mit Einschubende | 50 | 40 | 10 | DN 50 - 40 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/09262fc4-9bfd-4160-859d-f9a5b11852f3 | 32324 | 265.318
2 x Reduktion mit Einschubende | 40 | 20 | 10 | DN 40 - 20 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a6b82db2-e04b-426c-b6d0-0ccce4d2d0da | 32316 | 265.317
3 x Reduktion mit Einschubende | 25 | 20 | 10 | DN 25 - 20 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a0f47c2f-a359-42a1-bec5-568e625ae128 | 32309 | 265.315
Reduktion mit Einschubende | 32 | 25 | 10 | DN 32 - 25 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d9d4f277-164d-4038-9b59-23e6229ae887 | 32313 | 265.316
2 x Reduktion mit Einschubende | 25 | 15 | 10 | DN 25 - 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/1ec78e3b-b252-475d-b454-bf154aa799b8 | 32308 | 265.315
Reduktion mit Einschubende | 40 | 32 | 10 | DN 40 - 32 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/92459ca9-274e-48ce-bee1-002ebc4b1adb | 32318 | 265.317
Reduktion mit Einschubende | 50 | 32 | 40 | DN 50 - 32 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/ea40d7a2-5fe0-42c1-a6b9-6d40e7f60730 | 32323 | 265.318
Reduktion mit Einschubende | 80 | 50 | 10 | DN 80 - 50 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a6ce8764-36bf-42e5-974a-93d04ad22729 | 32338 | 265.322
Reduktion mit Einschubende | 65 | 50 | 10 | DN 65 - 50 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/2b66568e-4a86-4e4e-b50c-53132dd2133d | 32331 | 265.321
Reduktion mit Einschubende | 25 | 20 | 30 | DN 25 - 20 | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/a0f47c2f-a359-42a1-bec5-568e625ae128 | 32309 | 265.315
Reduktion mit Einschubende | 40 | 15 | 10 | DN 40 - 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/e9d15786-b5de-4973-9043-3ae14566201f | 32315 | 265.317
Reduktion mit Einschubende | 20 | 15 | 10 | DN 20 - 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/296711b6-e54f-48f9-9c91-1021a250df45 | 32306 | 265.314
Reduktion mit Einschubende | 32 | 25 | 10 | DN 32 - 25 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/d9d4f277-164d-4038-9b59-23e6229ae887 | 32313 | 265.316
Reduktion mit Einschubende | 25 | 20 | 10 | DN 25 - 20 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a0f47c2f-a359-42a1-bec5-568e625ae128 | 32309 | 265.315

# IfcFlowFitting: Rohrbogen (6)
In: Grundleitungsebene
Description: Rohrbogen
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Tech-DN: 100; Tech-Insulation thickness (mm): 0 mm; Name: Rohrbogen; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II; Tech-Medium: B_E-Kabel; Tech-Product item: Lokales Bauteil; Tech-Manufacturer: Geberit; Tech-Order number: 31111; Tech-Standard Number: 262.123

# IfcFlowFitting: Rohrnippel (2)
In: EG_Verwaltung_FFB
Description: Rohrnippel
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohrnippel; Tech-Catalog: Geberit; Tech-Product type: Rohrnippel; Tech-Manufacturer: Geberit
Name | Tech-DN1 = Tech-DN2 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Rohrnippel | 20 | 10 | DN 20 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/4b1fc68f-3423-4edf-9eda-eec27eba20ba | 32052 | 261.144
Rohrnippel | 40 | 0 | DN 40 | S_Umkehrosmosewasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a803be1c-5d3d-41b9-97e0-1162aa7d82e4 | 32055 | 261.147

# IfcFlowFitting: T-Stück egal (99)
In: EG_Verwaltung_FFB
Description: T-Stück egal
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: T-Stück egal; Tech-Catalog: Geberit; Tech-Product type: T-Stück egal; Tech-Manufacturer: Geberit
Name | Tech-DN1 = Tech-DN2 = Tech-DN3 | Tech-Insulation thickness (mm) (mm) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
2 x T-Stück egal | 25 | 40 | DN 25 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a972d8ef-cc05-4dd4-bfad-0bad4fc1fa09 | 31005 | 264.115
T-Stück egal | 32 | 20 | DN 32 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a74d0a0a-59c0-4a72-9c51-c7808dae2089 | 31006 | 264.116
T-Stück egal | 32 | 10 | DN 32 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a74d0a0a-59c0-4a72-9c51-c7808dae2089 | 31006 | 264.116
15 x T-Stück egal | 15 | 30 | DN 15 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/f69cfb38-ab29-49f8-aa18-452480659de2 | 31003 | 264.113
55 x T-Stück egal | 15 | 30 | DN 15 | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/f69cfb38-ab29-49f8-aa18-452480659de2 | 31003 | 264.113
7 x T-Stück egal | 12 | 30 | DN 12 |  | 5992b63d-acee-48f0-9c27-8831f02f2006/f68114ad-42ee-496b-8804-a19f326ebb04 | 31002 | 264.112
9 x T-Stück egal | 15 | 10 | DN 15 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/f69cfb38-ab29-49f8-aa18-452480659de2 | 31003 | 264.113
6 x T-Stück egal | 15 | 10 | DN 15 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/f69cfb38-ab29-49f8-aa18-452480659de2 | 31003 | 264.113
T-Stück egal | 40 | 10 | DN 40 | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/1e9eb051-3018-4ec5-98b8-1e1f40ca2356 | 31007 | 264.117
T-Stück egal | 25 | 10 | DN 25 | S_enthaertetes_Wasser | 5992b63d-acee-48f0-9c27-8831f02f2006/a972d8ef-cc05-4dd4-bfad-0bad4fc1fa09 | 31005 | 264.115
