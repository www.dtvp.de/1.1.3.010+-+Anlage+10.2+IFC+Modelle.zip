Properties of the parts of a building model (IFC2X3), part 3 of 10

# IfcFlowSegment: PE-Rohr (112)
Name | In | Pset_MEP, Geom-Length (mm) (mm) | Tech-DN | Tech-Medium | Info | Floor | Floor No. | Building = Building No.
PE-Rohr | Grundleitungsebene | 1290.88 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 2451.14 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 903.668 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 1899.16 | 70 | S_Schmutzwasser_Grundleitung | DN 70
PE-Rohr | Grundleitungsebene | 6760.2 | 70 | S_Schmutzwasser_Grundleitung | DN 70

# IfcFlowSegment: Rohr (255)
In: EG_Verwaltung_FFB
Description: Rohr
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Rohr
Name | Tech-DN | Tech-Medium | Pset_MEP, Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-Outside diameter (mm) (mm) = Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Tech-Product item
Rohr | 100 | S_Schmutzwasser | Pset_MEP - Geom-Length (mm): 4684 mm; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Rohr | 100 | S_Schmutzwasser | Pset_MEP - Geom-Length (mm): 6115.05 mm; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Rohr | 100 | S_Schmutzwasser | Pset_MEP - Geom-Length (mm): 7015 mm; Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Rohr | 100 | S_Schmutzwasser | Pset_MEP - Geom-Length (mm): 5002 mm
Rohr | 100 | S_Schmutzwasser | Pset_MEP - Geom-Length (mm): 6115.05 mm
Rohr | 25 | S_Kaltwasser | 52 | 10 | 25 | 17.3765 | 1.99974 | 1.0293 | 4.1 | Lokales Bauteil
Rohr | 20 | S_Kaltwasser | 20 | 10 | 20 | 16.9994 | 1.63942 | 0.494643 | 0.88 | Lokales Bauteil
Rohr | 20 | S_Kaltwasser | 2.5 | 10 | 20 | 16.9994 | 1.63942 | 0.494643 | 0.88 | Lokales Bauteil
Rohr | 20 | S_Kaltwasser | 52.3831 | 10 | 20 | 14.3245 | 1.48782 | 0.448902 | 0.74 | Lokales Bauteil
Rohr | 20 | S_Kaltwasser | 30.2085 | 10 | 20 | 14.3245 | 1.48782 | 0.448902 | 0.74 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 2.5 | 10 | 15 | 18.5009 | 1.49023 | 0.299628 | 0.39 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 6.96334 | 10 | 15 | 10.7096 | 1.09098 | 0.219354 | 0.26 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 40.3387 | 30 | 15 | 3.73927 | 0.696303 | 0.14 | 0.14 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 41 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 4.85463 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Kaltwasser | 38 | 10 | 15 | 1.48653 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil
Rohr | 12 | S_Zirkulation | 20.5718 | 30 | 12 | 0.169538 | 0.1 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 12 | S_Zirkulation | 14.0897 | 30 | 12 | 0.169538 | 0.1 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 12 | S_Zirkulation | 50 | 30 | 12 | 0.169538 | 0.1 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Rohr | 15 | S_Warmwasser | 45.163 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.246356 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 41.1998 | 30 | 15 | 6.36682 | 0.940531 | 0.189105 | 0.22 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 44.8931 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Kaltwasser | 20.5004 | 10 | 15 | 4.31062 | 0.646567 | 0.13 | 0.13 | Lokales Bauteil
Rohr | 12 | S_Zirkulation | 17 | 30 | 12 | 2.17451 | 0.440985 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 6.91775 | 1.18859 | 0.611789 | 1.32 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 7.60288 | 1.25396 | 0.645439 | 1.47 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 8.26695 | 1.31489 | 0.676796 | 1.62 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 8.91214 | 1.37203 | 0.706208 | 1.77 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 9.54023 | 1.42592 | 0.733948 | 1.92 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 10.1528 | 1.47698 | 0.760229 | 2.07 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 33.6955 | 10 | 25 | 10.1528 | 1.47698 | 0.760229 | 2.07 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.77314 | 10 | 25 | 10.1528 | 1.47698 | 0.760229 | 2.07 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 3.77314 | 10 | 25 | 10.4336 | 1.49994 | 0.772046 | 2.14 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.77314 | 10 | 25 | 10.711 | 1.52238 | 0.783598 | 2.21 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 55 | 10 | 25 | 10.986 | 1.54434 | 0.794901 | 2.28 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.77314 | 10 | 25 | 10.986 | 1.54434 | 0.794901 | 2.28 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 11.2583 | 1.56584 | 0.805967 | 2.35 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 55 | 10 | 25 | 11.5279 | 1.5869 | 0.816807 | 2.42 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 11.5279 | 1.5869 | 0.816807 | 2.42 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 11.7949 | 1.60755 | 0.827433 | 2.49 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 55 | 10 | 25 | 12.0594 | 1.62779 | 0.837856 | 2.56 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 12.0594 | 1.62779 | 0.837856 | 2.56 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 12.3215 | 1.64766 | 0.848083 | 2.63 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 12.5813 | 1.66717 | 0.858124 | 2.7 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 33.1545 | 10 | 25 | 12.8388 | 1.68633 | 0.867987 | 2.77 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.3016 | 10 | 25 | 12.8388 | 1.68633 | 0.867987 | 2.77 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 33.1545 | 10 | 25 | 13.0941 | 1.70516 | 0.87768 | 2.84 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 33.1545 | 10 | 25 | 13.3473 | 1.72368 | 0.887209 | 2.91 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 33.1545 | 10 | 25 | 13.5984 | 1.74189 | 0.896581 | 2.98 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 33.1545 | 10 | 25 | 13.8476 | 1.7598 | 0.905803 | 3.05 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 33.1545 | 10 | 25 | 14.0947 | 1.77744 | 0.914879 | 3.12 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 2.5 | 10 | 25 | 14.0947 | 1.77744 | 0.914879 | 3.12 | Lokales Bauteil
5 x Rohr | 15 | S_Warmwasser | 2.5 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 25 | S_Warmwasser | 2.5 | 40 | 25 | 7.62328 | 1.43635 | 0.739314 | 1.95 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Rohr | 20 | S_Kaltwasser | 6.50022 | 10 | 20 | 22.2096 | 1.90703 | 0.575386 | 1.17 | Lokales Bauteil
Rohr | 12 | S_Zirkulation | 17 | 30 | 12 | 0.735036 | 0.236021 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 6.87127 | 1.18405 | 0.609454 | 1.31 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 50.4686 | 10 | 25 | 7.55788 | 1.24975 | 0.643271 | 1.46 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 7.87091 | 1.27883 | 0.658235 | 1.53 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 8.17955 | 1.30699 | 0.672734 | 1.6 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 8.48402 | 1.33432 | 0.686801 | 1.67 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 8.78452 | 1.36087 | 0.700467 | 1.74 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 9.08123 | 1.3867 | 0.713759 | 1.81 | Lokales Bauteil
2 x Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 9.37432 | 1.41184 | 0.726701 | 1.88 | Lokales Bauteil
Rohr | 25 | S_Kaltwasser | 3.93119 | 10 | 25 | 9.66393 | 1.43635 | 0.739314 | 1.95 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 38.426 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 41.426 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0442935 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 20 | S_Kaltwasser | 37.22 | 10 | 20 | 16.6243 | 1.61883 | 0.488432 | 0.86 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 15.3576 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0478775 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 23.0486 | 30 | 15 | 1.10798 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0418074 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Kaltwasser | 24.2892 | 10 | 15 | 1.48653 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 34 | 10 | 15 | 11.9271 | 1.16025 | 0.233282 | 0.28 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 34 | 10 | 15 | 7.65506 | 0.900005 | 0.180957 | 0.21 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 34 | 10 | 15 | 1.48653 | 0.348151 | 0.07 | 0.07 | Lokales Bauteil
Rohr | 100 | S_Kaltwasser | 90 | 10 | 100 | 1.19769 | 1.16541 | 9.9 | 25.18 | Lokales Bauteil
Rohr | 100 | S_Kaltwasser | 90 | 10 | 100 | 1.19769 | 1.16541 | 9.9 | 26.18 | Lokales Bauteil
Rohr | 100 | S_Kaltwasser | 140 | 10 | 100 | 1.19769 | 1.16541 | 9.9 | 26.18 | Lokales Bauteil
Rohr | 20 | S_enthaertetes_Wasser | 20 | 10 | 20 | 23.5679 | 1.97204 | 0.595 | 0.73 | Lokales Bauteil
2 x Rohr | 15 | S_Warmwasser | 49.7293 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 6.71145 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 32.8236 | 30 | 15 | 7.66986 | 1.04445 | 0.21 | 0.3 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0506095 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 19.1011 | 1.74076 | 0.35 | 0.5 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 50 | S_Warmwasser | 70 | 70 | 50 | 3.21012 | 1.41177 | 2.884 | 4.12 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.474454 mm3/s; Calc-Thermal loss (W/m): 10.4711 W/m
Rohr | 65 | S_enthaertetes_Wasser | 31 | 10 | 65 | 3.31221 | 1.60453 | 6.551 | 8.51 | Lokales Bauteil
Rohr | 65 | S_enthaertetes_Wasser | 29.0574 | 10 | 65 | 3.31221 | 1.60453 | 6.551 | 8.51 | Lokales Bauteil
Rohr | 65 | S_enthaertetes_Wasser | 112.132 | 10 | 65 | 3.31221 | 1.60453 | 6.551 | 8.51 | Lokales Bauteil
2 x Rohr | 50 | S_enthaertetes_Wasser | 87.4214 | 10 | 50 | 3.55828 | 1.31925 | 2.695 | 3.61 | Lokales Bauteil
3 x Rohr | 15 | S_enthaertetes_Wasser | 36.6304 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 19.1668 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0555045 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0662018 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 13.3656 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 43.1599 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0662018 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 38.7107 | 30 | 12 | 6.3431 | 0.811442 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 15 | S_enthaertetes_Wasser | 8.7664 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
2 x Rohr | 15 | S_enthaertetes_Wasser | 24.549 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 24.629 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
2 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0757933 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 17.19 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0614415 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 20 | S_Warmwasser | 28.7107 | 30 | 20 | 13.16 | 1.62403 | 0.49 | 0.7 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107705 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Rohr | 15 | S_Warmwasser | 6.99493 | 30 | 15 | 19.1011 | 1.74076 | 0.35 | 0.5 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 40.7476 | 30 | 15 | 12.8088 | 1.39261 | 0.28 | 0.4 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 38.7391 | 10 | 15 | 4.901 | 0.696303 | 0.14 | 0.2 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 4.86431 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 3.73927 | 0.696303 | 0.14 | 0.2 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 24.2371 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 43.986 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 7.66986 | 1.04445 | 0.21 | 0.3 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
3 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_enthaertetes_Wasser | 38.7391 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 33.894 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 44 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 40 | S_enthaertetes_Wasser | 28.7107 | 10 | 40 | 10.0817 | 1.96804 | 2.351 | 2.75 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 15.9371 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 46 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 8.88721 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0695414 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 42 | 30 | 12 | 1.44349 | 0.348544 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0462631 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 15 | S_enthaertetes_Wasser | 39.9493 | 10 | 15 | 16.4247 | 1.39261 | 0.28 | 0.28 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 25.7597 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0757933 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 45.9873 | 30 | 12 | 0.880637 | 0.262072 | 0.28 | 0.28 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 12 | S_Zirkulation | 42 | 30 | 12 | 0.880637 | 0.262072 | 0.28 | 0.28 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 15 | S_Warmwasser | 8.01846 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0466969 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_enthaertetes_Wasser | 13.137 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 34 | 10 | 15 | 4.901 | 0.696303 | 0.14 | 0.2 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 38 | 10 | 15 | 9.92436 | 1.04445 | 0.21 | 0.3 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 31.6468 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0309313 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0309313 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 13.2279 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0309313 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 31.6013 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0309313 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 20.411 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 37.7721 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 50 | 30 | 12 | 0.371591 | 0.15864 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 15 | S_Warmwasser | 26.6478 | 30 | 15 | 7.66986 | 1.04445 | 0.21 | 0.3 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 41 | 30 | 15 | 7.66986 | 1.04445 | 0.21 | 0.3 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0210567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 3.73927 | 0.696303 | 0.14 | 0.2 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 29.4101 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0347855 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 35.2448 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0466969 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 15.9247 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 5.86235 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 10.0923 | 1.21853 | 0.245 | 0.35 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 46 | 30 | 15 | 10.0923 | 1.21853 | 0.245 | 0.35 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 19.4643 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0411514 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Kaltwasser | 19.6127 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 41 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 20 | S_enthaertetes_Wasser | 37 | 10 | 20 | 16.7186 | 1.62403 | 0.49 | 0.7 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 5.27995 | 10 | 15 | 28.7747 | 1.91483 | 0.385 | 0.55 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0340671 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 47.2239 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0340671 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 47.3039 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0340671 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 45.8044 | 30 | 12 | 0.767703 | 0.242047 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 5.5492 | 0.870379 | 0.175 | 0.25 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0321275 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 25 | S_enthaertetes_Wasser | 24 | 10 | 25 | 7.28498 | 1.22397 | 0.63 | 0.9 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 44 | 30 | 15 | 3.73927 | 0.696303 | 0.14 | 0.2 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 41 | 10 | 15 | 8.58728 | 0.961346 | 0.19329 | 0.2 | Lokales Bauteil
2 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0362358 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 35.2498 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0362358 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 28.2498 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0362358 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 44.4861 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 7.89618 | 30 | 12 | 0.49191 | 0.186872 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0248039 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 15 | S_Warmwasser | 41 | 30 | 15 | 7.66986 | 1.04445 | 0.21 | 0.3 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0230223 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 5.13293 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0202295 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 17.0566 | 10 | 15 | 13.4639 | 1.2434 | 0.25 | 0.35 | Lokales Bauteil
2 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0202295 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 47.5432 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0202295 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 47.6232 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0202295 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 17.0566 | 10 | 15 | 20.2024 | 1.56668 | 0.315 | 0.45 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 38 | 10 | 15 | 28.7747 | 1.91483 | 0.385 | 0.55 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 32.6957 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0202295 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 13.057 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 19.6503 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0466969 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 49.5703 | 30 | 15 | 10.4626 | 1.2434 | 0.25 | 0.25 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 20 | S_enthaertetes_Wasser | 2.5 | 10 | 20 | 12.7395 | 1.39203 | 0.42 | 0.6 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 42.4494 | 10 | 15 | 13.4639 | 1.2434 | 0.25 | 0.25 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 23.0897 | 30 | 15 | 10.4626 | 1.2434 | 0.25 | 0.25 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 47.9493 | 30 | 15 | 10.4626 | 1.2434 | 0.25 | 0.25 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Rohr | 15 | S_Warmwasser | 47.4671 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0719645 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 2.5 | 10 | 15 | 13.4639 | 1.2434 | 0.25 | 0.25 | Lokales Bauteil
2 x Rohr | 12 | S_Zirkulation | 42 | 30 | 12 | 2.5335 | 0.48129 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0638827 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Rohr | 15 | S_Warmwasser | 46.6837 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0675829 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 27.0996 | 30 | 12 | 0.169538 | 0.1 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
3 x Rohr | 15 | S_enthaertetes_Wasser | 6.01414 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 21.4636 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
2 x Rohr | 32 | S_enthaertetes_Wasser | 16 | 10 | 32 | 7.33359 | 1.43612 | 1.155 | 1.41 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0143357 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 5.20745 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 12 | S_Zirkulation | 42 | 30 | 12 | 2.03555 | 0.424609 |  |  | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
3 x Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 23.0135 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Kaltwasser | 17.4286 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_Kaltwasser | 17.5086 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 17.5086 | 10 | 15 | 2.74061 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 34 | 10 | 15 | 28.7747 | 1.91483 | 0.385 | 0.55 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 37.2999 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 35.5998 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 49.2999 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0586851 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_enthaertetes_Wasser | 22.4928 | 10 | 15 | 12.9957 | 1.21853 | 0.245 | 0.35 | Lokales Bauteil
Rohr | 15 | S_enthaertetes_Wasser | 18.1915 | 10 | 15 | 8.79835 | 0.974824 | 0.196 | 0.28 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 44.8726 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 15 | S_Warmwasser | 34 | 30 | 15 | 6.36054 | 0.940009 | 0.189 | 0.27 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0563593 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Rohr | 80 | S_enthaertetes_Wasser | 750.267 | 10 | 80 | 2.9096 | 1.66662 | 9.435 | 12.63 | Lokales Bauteil
Rohr | 40 | S_Umkehrosmosewasser | 28.7107 | 10 | 40 | 5.43429 | 1.39127 | 1.662 | 1.662 | Lokales Bauteil
Rohr | 15 | S_Umkehrosmosewasser | 47.5537 | 10 | 15 | 16.117 | 1.37768 | 0.277 | 0.277 | Lokales Bauteil
Rohr | 15 | S_Warmwasser | 42 | 30 | 15 | 2.06793 | 0.497359 | 0.1 | 0.1 | Lokales Bauteil | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0530563 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Description: Systemrohr CrNiMo
Pset_FM-Vivantes - Klasse: i.B.; Bezeichnung: i.B.; AKS: i.B.; Anzahl: 0; Standort: i.B.; Hersteller: i.B.; Hersteller-Typ: i.B.; Seriennummer: i.B.; Baujahr: 0; Inbetriebnahme Datum: i.B.; Gewährleistungsende: i.B.; Gewährleistungsgeber: i.B.; Betriebsstatus: i.B.; Prüfpflicht: no; Prüfintervall: 0; Letzter Prüfungstermin: i.B.; Sammelobjekt: no; rechn. Lebensdauer: 0; rechn. Lebensende: i.B.; technischer Zustand: i.B.; voraus. Lebensende: i.B.; Eigentümer: i.B.; Bemerkung: i.B.; Versorgungsbereich-Wirkbereich: i.B.; Zugänglichkeit: i.B.
Pset_MEP - Name: Systemrohr CrNiMo; Tech-Catalog: Geberit; Tech-Product type: Systemrohr CrNiMo; Tech-Manufacturer: Geberit
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 274 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 274 | 10 | 20 | 22 | 19.6 | 19.5653 | 1.77518 | 0.535604 | 1.02 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Systemrohr CrNiMo | EG_Verwaltung_FFB | 274 | 10 | 20 | 22 | 19.6 | 18.295 | 1.70903 | 0.515645 | 0.95 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Systemrohr CrNiMo | EG_Verwaltung_FFB | 274 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Systemrohr CrNiMo | EG_Verwaltung_FFB | 274 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 18.5009 | 1.49023 | 0.299628 | 0.39 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 10.7096 | 1.09098 | 0.219354 | 0.26 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 432 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 432 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | - | Pset_MEP - Floor: EG_Verwaltung_FFB; Floor No.: 0; Building: Speiseverteilzentrum SBW VZ II; Building No.: Speiseverteilzentrum SBW VZ II
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 13.4745 | 1.97041 | 1.01421 | 3.96 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.165113 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5392.53 | 40 | 25 | 28 | 25.6 | 13.4745 | 1.97041 | 1.01421 | 3.96 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.165113 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2359.36 | 10 | 32 | 35 | 32 | 6.28243 | 1.31609 | 1.05846 | 4.38 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 32 | 35 | 32 | 8.85283 | 1.59681 | 1.28423 | 7.01 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5680.53 | 10 | 32 | 35 | 32 | 8.85283 | 1.59681 | 1.28423 | 7.01 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 32 | 35 | 32 | 6.09918 | 1.29427 | 1.04092 | 4.21 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4342.95 | 10 | 32 | 35 | 32 | 6.09918 | 1.29427 | 1.04092 | 4.21 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 8.74742 | 1.55053 | 0.798086 | 2.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107239 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4357.8 | 40 | 25 | 28 | 25.6 | 8.74742 | 1.55053 | 0.798086 | 2.3 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107239 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 5.00593 | 0.821205 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.165113 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5092.53 | 30 | 15 | 18 | 16 | 5.00593 | 0.821205 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.165113 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1893 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 6.29478 | 0.807935 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107239 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4358.8 | 30 | 12 | 15 | 13 | 6.29478 | 0.807935 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.107239 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 762 | 40 | 25 | 28 | 25.6 | 7.39076 | 1.41184 | 0.726701 | 1.88 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 762 | 40 | 25 | 28 | 25.6 | 7.15604 | 1.3867 | 0.713759 | 1.81 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 762 | 40 | 25 | 28 | 25.6 | 6.91854 | 1.36087 | 0.700467 | 1.74 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 762 | 40 | 25 | 28 | 25.6 | 6.67813 | 1.33432 | 0.686801 | 1.67 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 762 | 40 | 25 | 28 | 25.6 | 6.18806 | 1.27883 | 0.658235 | 1.53 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 609 | 40 | 25 | 28 | 25.6 | 5.93809 | 1.24975 | 0.643271 | 1.46 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 115 | 40 | 25 | 28 | 25.6 | 5.68461 | 1.2197 | 0.627804 | 1.39 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 609 | 40 | 25 | 28 | 25.6 | 5.42732 | 1.18859 | 0.611789 | 1.32 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 82 | 30 | 20 | 22 | 19.6 | 18.671 | 1.97262 | 0.595177 | 1.25 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 615 | 30 | 20 | 22 | 19.6 | 17.7056 | 1.9154 | 0.57791 | 1.18 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 121 | 30 | 20 | 22 | 19.6 | 16.7259 | 1.85577 | 0.559921 | 1.11 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 762 | 30 | 20 | 22 | 19.6 | 15.7297 | 1.7935 | 0.541132 | 1.04 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 768 | 30 | 20 | 22 | 19.6 | 14.7159 | 1.72826 | 0.521448 | 0.97 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1091 | 30 | 20 | 22 | 19.6 | 11.4018 | 1.49927 | 0.452358 | 0.75 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1078 | 30 | 15 | 18 | 16 | 23.9215 | 1.97316 | 0.396727 | 0.6 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1092 | 30 | 15 | 18 | 16 | 17.2302 | 1.64355 | 0.330456 | 0.45 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1092 | 30 | 15 | 18 | 16 | 10.2058 | 1.22619 | 0.24654 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1092 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1092 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1092 | 30 | 15 | 18 | 16 | 10.2058 | 1.22619 | 0.24654 | 0.3 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 723 | 30 | 20 | 22 | 19.6 | 18.397 | 1.9565 | 0.590313 | 1.23 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 768 | 30 | 20 | 22 | 19.6 | 17.4274 | 1.89862 | 0.572847 | 1.16 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 768 | 30 | 20 | 22 | 19.6 | 15.4419 | 1.77518 | 0.535604 | 1.02 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 768 | 30 | 20 | 22 | 19.6 | 14.4229 | 1.70903 | 0.515645 | 0.95 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 209.001 | 30 | 20 | 22 | 19.6 | 13.3848 | 1.63942 | 0.494643 | 0.88 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 526.999 | 30 | 20 | 22 | 19.6 | 12.3258 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 209.001 | 30 | 20 | 22 | 19.6 | 11.2461 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 523.999 | 30 | 20 | 22 | 19.6 | 10.1424 | 1.40448 | 0.423757 | 0.67 | DN 20 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 9.78109 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1092 | 30 | 15 | 18 | 16 | 17.2302 | 1.64355 | 0.330456 | 0.45 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0313276 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 119.004 | 20 | 32 | 35 | 32 | 12.9543 | 1.97772 | 1.59058 | 12.09 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 12.7052 | 1.9073 | 0.98172 | 3.67 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 654.236 | 40 | 25 | 28 | 25.6 | 12.7052 | 1.9073 | 0.98172 | 3.67 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2679.09 | 40 | 25 | 28 | 25.6 | 12.7052 | 1.9073 | 0.98172 | 3.67 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 152 | 40 | 25 | 28 | 25.6 | 12.7052 | 1.9073 | 0.98172 | 3.67 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 388.228 | 40 | 25 | 28 | 25.6 | 12.7052 | 1.9073 | 0.98172 | 3.67 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3571 | 40 | 25 | 28 | 25.6 | 13.8391 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196862 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 13.8391 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196862 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 78.0497 | 40 | 25 | 28 | 25.6 | 13.8391 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196862 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 802 | 40 | 25 | 28 | 25.6 | 13.8391 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196862 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 581.253 | 40 | 25 | 28 | 25.6 | 13.8391 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196862 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 124 | 40 | 25 | 28 | 25.6 | 13.8391 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196862 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2493.92 | 10 | 25 | 28 | 25.6 | 17.3765 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3571 | 10 | 25 | 28 | 25.6 | 17.3765 | 1.99974 | 1.0293 | 4.1 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 127 | 10 | 32 | 35 | 32 | 9.47252 | 1.65878 | 1.33407 | 7.71 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 745.253 | 10 | 32 | 35 | 32 | 9.47252 | 1.65878 | 1.33407 | 7.71 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 816 | 10 | 32 | 35 | 32 | 9.47252 | 1.65878 | 1.33407 | 7.71 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1698.76 | 10 | 32 | 35 | 32 | 9.47252 | 1.65878 | 1.33407 | 7.71 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 32 | 35 | 32 | 8.33102 | 1.54312 | 1.24105 | 6.44 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 654.236 | 10 | 32 | 35 | 32 | 8.33102 | 1.54312 | 1.24105 | 6.44 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2841.09 | 10 | 32 | 35 | 32 | 8.33102 | 1.54312 | 1.24105 | 6.44 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 166 | 10 | 32 | 35 | 32 | 8.33102 | 1.54312 | 1.24105 | 6.44 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 240.228 | 10 | 32 | 35 | 32 | 8.33102 | 1.54312 | 1.24105 | 6.44 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 480.769 | 10 | 32 | 35 | 32 | 8.26578 | 1.5363 | 1.23557 | 6.37 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 966 | 10 | 32 | 35 | 32 | 8.26578 | 1.5363 | 1.23557 | 6.37 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 32 | 35 | 32 | 8.26578 | 1.5363 | 1.23557 | 6.37 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 847.421 | 10 | 32 | 35 | 32 | 8.26578 | 1.5363 | 1.23557 | 6.37 | DN 32 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/06d4edd8-04fc-4dc7-8b11-5ebd9e5bf517 | 39006 | 261.116
Systemrohr CrNiMo | EG_Verwaltung_FFB | 260 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 90.9537 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 90.1939 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2260 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 420.954 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1095.56 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 185.281 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 220 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3503.24 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 431 | 10 | 20 | 22 | 19.6 | 20.8119 | 1.83826 | 0.554638 | 1.09 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 260 | 10 | 20 | 22 | 19.6 | 19.5653 | 1.77518 | 0.535604 | 1.02 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
