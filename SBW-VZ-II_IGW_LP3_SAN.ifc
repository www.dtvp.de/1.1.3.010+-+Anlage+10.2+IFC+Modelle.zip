Properties of the parts of a building model (IFC2X3), part 4 of 10

# IfcFlowSegment: Systemrohr CrNiMo (1759)
Name | In | Geom-Length (mm) (m) | Tech-Insulation thickness (mm) (mm) | Tech-DN | Tech-Outside diameter (mm) (mm) | Tech-Inside diameter (mm) (mm) | Calc-R (mbar/m) (hPa/m) | Calc-Velocitiy (m/s) (m/s) | Calc-Design vol flow (l/s) (mm3/s) | Calc-Total volumetric flow (l/s) (mm3/s) | Info | Tech-Medium | Tech-Product item | Tech-Order number | Tech-Standard Number
Systemrohr CrNiMo | EG_Verwaltung_FFB | 90.9537 | 10 | 20 | 22 | 19.6 | 19.5653 | 1.77518 | 0.535604 | 1.02 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 73 | 10 | 20 | 22 | 19.6 | 19.5653 | 1.77518 | 0.535604 | 1.02 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2560 | 10 | 20 | 22 | 19.6 | 18.295 | 1.70903 | 0.515645 | 0.95 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2358.76 | 10 | 20 | 22 | 19.6 | 18.295 | 1.70903 | 0.515645 | 0.95 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 321.167 | 10 | 20 | 22 | 19.6 | 18.295 | 1.70903 | 0.515645 | 0.95 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 260 | 10 | 20 | 22 | 19.6 | 18.295 | 1.70903 | 0.515645 | 0.95 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 374.5 | 10 | 20 | 22 | 19.6 | 16.9994 | 1.63942 | 0.494643 | 0.88 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 260 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 116.92 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2410 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4030.17 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2378.42 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 200 | 10 | 20 | 22 | 19.6 | 15.6765 | 1.56588 | 0.472456 | 0.81 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 60 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2410 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1711.47 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1452.59 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 175.032 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 260 | 10 | 20 | 22 | 19.6 | 14.3245 | 1.48782 | 0.448902 | 0.74 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 267 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 78.7915 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 321.894 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2424 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1334.21 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 238.862 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 52.6403 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 30.8819 | 1.993 | 0.400717 | 0.61 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 267 | 10 | 15 | 18 | 16 | 27.052 | 1.84902 | 0.371767 | 0.54 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 78.7915 | 10 | 15 | 18 | 16 | 27.052 | 1.84902 | 0.371767 | 0.54 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 113.823 | 10 | 15 | 18 | 16 | 27.052 | 1.84902 | 0.371767 | 0.54 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 94.2085 | 10 | 15 | 18 | 16 | 27.052 | 1.84902 | 0.371767 | 0.54 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 457 | 10 | 15 | 18 | 16 | 27.052 | 1.84902 | 0.371767 | 0.54 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 457 | 10 | 15 | 18 | 16 | 18.5009 | 1.49023 | 0.299628 | 0.39 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 94.2085 | 10 | 15 | 18 | 16 | 18.5009 | 1.49023 | 0.299628 | 0.39 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1065.8 | 10 | 15 | 18 | 16 | 18.5009 | 1.49023 | 0.299628 | 0.39 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 18.5009 | 1.49023 | 0.299628 | 0.39 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 10.7096 | 1.09098 | 0.219354 | 0.26 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 94.2085 | 10 | 15 | 18 | 16 | 10.7096 | 1.09098 | 0.219354 | 0.26 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1171.04 | 10 | 15 | 18 | 16 | 10.7096 | 1.09098 | 0.219354 | 0.26 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 67 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 94.2085 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1068.81 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 467 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0478775 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 130.951 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0478775 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 385.746 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2224 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1749.53 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 249.621 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 452.92 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2224 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4409.89 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2611.78 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 152.737 | 30 | 15 | 18 | 16 | 5.8882 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2374 | 30 | 15 | 18 | 16 | 5.8882 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2379.33 | 30 | 15 | 18 | 16 | 5.8882 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 461.599 | 30 | 15 | 18 | 16 | 5.8882 | 0.900005 | 0.180957 | 0.21 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 211.861 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0478775 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 68.982 | 30 | 15 | 18 | 16 | 9.24823 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 58.8613 | 30 | 15 | 18 | 16 | 9.24823 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 482.065 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2074 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 166.327 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 995.965 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 296.315 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 234 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3817.24 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 441 | 30 | 15 | 18 | 16 | 12.5815 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.048706 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 328.769 | 40 | 25 | 28 | 25.6 | 12.5164 | 1.89155 | 0.973615 | 3.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 952 | 40 | 25 | 28 | 25.6 | 12.5164 | 1.89155 | 0.973615 | 3.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 40 | 25 | 28 | 25.6 | 12.5164 | 1.89155 | 0.973615 | 3.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 996.568 | 40 | 25 | 28 | 25.6 | 12.5164 | 1.89155 | 0.973615 | 3.6 | DN 25 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 9.70716 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 148.09 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2474 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 832.095 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1455.71 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 563.197 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1484 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2615.92 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 167 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 84.6765 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 113.09 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2674 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 916.273 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1518.93 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 629.973 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1484 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2465.92 | 10 | 15 | 18 | 16 | 1.48653 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2482 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 624.273 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1277.93 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 648.973 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 1492 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2773.92 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 4.31603 | 0.755189 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 675.236 | 30 | 15 | 18 | 16 | 4.31603 | 0.755189 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2561.09 | 30 | 15 | 18 | 16 | 4.31603 | 0.755189 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 184 | 30 | 15 | 18 | 16 | 4.31603 | 0.755189 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 559.228 | 30 | 15 | 18 | 16 | 4.31603 | 0.755189 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.15184 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 3587 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 94 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 299.413 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 88.4395 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 76.2722 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 395.925 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 834 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 463.253 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 146 | 30 | 15 | 18 | 16 | 6.83789 | 0.97911 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.196861 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1129.71 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1082.3 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 901.347 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1504.45 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2192 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 207.591 | 30 | 12 | 15 | 13 | 0.752158 | 0.239193 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 492 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.246356 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 86.2695 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 239.271 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2234 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 1849.56 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 94 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
3 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 10 | 20 | 22 | 19.6 | 13.5379 | 1.4409 | 0.434745 | 0.7 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 483.714 | 10 | 20 | 22 | 19.6 | 13.5379 | 1.4409 | 0.434745 | 0.7 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 270 | 10 | 20 | 22 | 19.6 | 13.5379 | 1.4409 | 0.434745 | 0.7 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 756.298 | 10 | 20 | 22 | 19.6 | 13.5379 | 1.4409 | 0.434745 | 0.7 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1032.67 | 10 | 20 | 22 | 19.6 | 13.5379 | 1.4409 | 0.434745 | 0.7 | DN 20 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/7a0f0551-feef-4e24-b263-41069abd4224 | 39004 | 261.114
Systemrohr CrNiMo | EG_Verwaltung_FFB | 242.807 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2384 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5828.82 | 10 | 15 | 18 | 16 | 16.1382 | 1.37872 | 0.277207 | 0.35 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 86.2695 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1260.5 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 292 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 92 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 96.2695 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 859.643 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 86.2695 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 292.936 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 2184 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 1496.45 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 4452.55 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 324.513 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 310.547 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2184 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1646.45 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 815.115 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 845.667 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 284 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 801.714 | 30 | 15 | 18 | 16 | 3.73927 | 0.696303 | 0.14 | 0.14 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0317487 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 827.912 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 904 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 237.095 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1177.03 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1806.53 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 690.49 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 471.253 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 100 | 30 | 12 | 15 | 13 | 0.169538 | 0.1 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 357 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 54.8931 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 557 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 307.466 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 705.612 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 90.5344 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 757 | 10 | 15 | 18 | 16 | 11.9271 | 1.16025 | 0.233282 | 0.28 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 757 | 10 | 15 | 18 | 16 | 20.8288 | 1.5941 | 0.320514 | 0.43 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 90.5344 | 10 | 15 | 18 | 16 | 20.8288 | 1.5941 | 0.320514 | 0.43 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1002.29 | 10 | 15 | 18 | 16 | 20.8288 | 1.5941 | 0.320514 | 0.43 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 297.466 | 10 | 15 | 18 | 16 | 20.8288 | 1.5941 | 0.320514 | 0.43 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 139.815 | 10 | 15 | 18 | 16 | 24.8189 | 1.76087 | 0.354044 | 0.5 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 407.298 | 10 | 15 | 18 | 16 | 24.8189 | 1.76087 | 0.354044 | 0.5 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 279.46 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2674 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1721.22 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 671.49 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1484 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 763.253 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 88 | 10 | 15 | 18 | 16 | 28.7053 | 1.91222 | 0.384474 | 0.57 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 56.0122 | 30 | 15 | 18 | 16 | 1.10798 | 0.348151 | 0.07 | 0.07 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 648.972 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2474 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1756.16 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 702.869 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1484 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 613.253 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 91 | 30 | 15 | 18 | 16 | 9.7274 | 1.19361 | 0.23999 | 0.29 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 179.895 | 30 | 15 | 18 | 16 | 6.36682 | 0.940531 | 0.189105 | 0.22 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 87 | 30 | 15 | 18 | 16 | 6.36682 | 0.940531 | 0.189105 | 0.22 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0132732 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 167 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 90.5344 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 307.466 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 557 | 10 | 15 | 18 | 16 | 4.31062 | 0.646567 | 0.13 | 0.13 | DN 15 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113
Systemrohr CrNiMo | EG_Verwaltung_FFB | 199.769 | 30 | 15 | 18 | 16 | 3.67195 | 0.689174 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 984 | 30 | 15 | 18 | 16 | 3.67195 | 0.689174 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 15 | 18 | 16 | 3.67195 | 0.689174 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 1167.57 | 30 | 15 | 18 | 16 | 3.67195 | 0.689174 |  |  | DN 15 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.138567 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 57.1213 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2307 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 550.705 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 6000 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 825.34 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 2904.6 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 349.059 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 442 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 5971.53 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
Systemrohr CrNiMo | EG_Verwaltung_FFB | 51 | 30 | 12 | 15 | 13 | 2.17451 | 0.440985 |  |  | DN 12 6m | S_Zirkulation | 5992b63d-acee-48f0-9c27-8831f02f2006/4ff06123-7fec-4528-b8a7-fc70b6783da9 | 39002 | 261.112 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.058533 mm3/s; Calc-Thermal loss (W/m): 8.05487 W/m
6 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 57 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
4 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 139.396 | 30 | 15 | 18 | 16 | 4.224 | 0.746039 | 0.15 | 0.15 | DN 15 6m | S_Warmwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/23c20045-33fd-4aca-b8de-f81334688c86 | 39003 | 261.113 | Pset_MEP - Calc-Velocitiy circulation (l/s): 0.0793324 mm3/s; Calc-Thermal loss (W/m): 8.81063 W/m
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 241 | 10 | 25 | 28 | 25.6 | 6.91775 | 1.18859 | 0.611789 | 1.32 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 967.698 | 10 | 25 | 28 | 25.6 | 6.91775 | 1.18859 | 0.611789 | 1.32 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 241 | 10 | 25 | 28 | 25.6 | 7.60288 | 1.25396 | 0.645439 | 1.47 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
Systemrohr CrNiMo | EG_Verwaltung_FFB | 975.47 | 10 | 25 | 28 | 25.6 | 7.60288 | 1.25396 | 0.645439 | 1.47 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
2 x Systemrohr CrNiMo | EG_Verwaltung_FFB | 241 | 10 | 25 | 28 | 25.6 | 8.26695 | 1.31489 | 0.676796 | 1.62 | DN 25 6m | S_Kaltwasser | 5992b63d-acee-48f0-9c27-8831f02f2006/6f48ec83-8e33-428a-b03c-b7dc36a753d2 | 39005 | 261.115
